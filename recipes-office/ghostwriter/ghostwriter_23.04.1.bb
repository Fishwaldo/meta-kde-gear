# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ghostwriter-${PV}.tar.xz"
SRC_URI[sha256sum] = "ac7182a7a3a4e0010f39969df9265fd0ddb5c22e9451ae3ccaee9489e0bc8f2c"

