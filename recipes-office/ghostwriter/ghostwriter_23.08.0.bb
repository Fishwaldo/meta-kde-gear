# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ghostwriter-${PV}.tar.xz"
SRC_URI[sha256sum] = "c4f7ef72de068b2e57abb35e1b6ea2fc8503f09f784c3ec2a6c0f5d15b58acaf"

