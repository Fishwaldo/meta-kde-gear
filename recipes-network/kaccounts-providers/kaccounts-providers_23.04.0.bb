require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kaccounts-providers-23.04.0.tar.xz"
SRC_URI[sha256sum] = "cf37813acf5b1895d5a6d2315c60f186ccd7b798ef7bb3b0ad98bd6e29547b1e"
