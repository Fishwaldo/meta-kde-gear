# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kaccounts-providers-${PV}.tar.xz"
SRC_URI[sha256sum] = "50ff9336acb5db4809485fcda0629dd549dec5744767995ae62e1b54c2075b22"

