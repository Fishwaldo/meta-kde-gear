require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kaccounts-providers-${PV}.tar.xz"
SRC_URI[sha256sum] = "969b4c9245b4b390f0960602f0e45668ea5632ac08653f476e3a5147446a3fef"
