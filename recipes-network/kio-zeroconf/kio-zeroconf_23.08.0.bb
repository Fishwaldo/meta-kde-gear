# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kio-zeroconf-${PV}.tar.xz"
SRC_URI[sha256sum] = "e227ce17a782802b9f8d14a638829c4381fece8eacb084c1fda84a940d9d40a4"

