# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kio-zeroconf-${PV}.tar.xz"
SRC_URI[sha256sum] = "c6e94b7cf2cd17c897cc35f6c93fddcb5b339c4352365ad2b012097d45ddb544"

