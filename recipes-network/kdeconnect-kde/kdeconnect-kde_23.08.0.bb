# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdeconnect-kde-${PV}.tar.xz"
SRC_URI[sha256sum] = "8b41c674f99929efa1c5b85c30bd3fa07d242d32c9065dd6d422a5802601d5e9"

