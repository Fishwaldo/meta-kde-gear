# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdeconnect-kde-${PV}.tar.xz"
SRC_URI[sha256sum] = "070b34e0bea84c65fe8cef75ddf989ea136d8bba5f3eccf061c19383977d09c4"

