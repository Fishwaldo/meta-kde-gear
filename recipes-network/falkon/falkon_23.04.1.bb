# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/falkon-${PV}.tar.xz"
SRC_URI[sha256sum] = "c56bc0224d6df90ae9959a8ee81dfe5ef570db2452040c7219d2939237019f02"

