# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/falkon-${PV}.tar.xz"
SRC_URI[sha256sum] = "62a586e8f8c25402400a38d002e8cf70b6f45377dada02bf54cb87a847b1e571"

