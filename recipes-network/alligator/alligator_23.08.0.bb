# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/alligator-${PV}.tar.xz"
SRC_URI[sha256sum] = "2dcc2ec4960d81da4ab195a5d1c4be8c3d21c3f3ab75697e0d8262b5e3208d04"

