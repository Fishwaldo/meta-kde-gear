# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.1/src/alligator-23.04.1.tar.xz"
SRC_URI[sha256sum] = "70c81a86ddda7bf34d11119e8848061e8753e0f1354bbef53ccecd37db04ac22"

