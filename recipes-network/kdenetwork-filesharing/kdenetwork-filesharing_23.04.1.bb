# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdenetwork-filesharing-${PV}.tar.xz"
SRC_URI[sha256sum] = "91db205a7dd60840678b571bfcb4a30daa78602ba0eb418fd3ae8699ceacefc1"

