# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdenetwork-filesharing-${PV}.tar.xz"
SRC_URI[sha256sum] = "ced72981e38deccef00c800a214ece53ea689c11554308c9a13b9af536d9392a"

