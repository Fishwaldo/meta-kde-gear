# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libktorrent-${PV}.tar.xz"
SRC_URI[sha256sum] = "63cb152864392c6b2d8dc176459b35f80eb8c68c4b9aca3fc1a764d5374035ce"

