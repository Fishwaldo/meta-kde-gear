# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kio-extras-${PV}.tar.xz"
SRC_URI[sha256sum] = "d8706b84f9a95767b85c27f4718e9905f35ee873f2acca25d5c51e55ff182ad9"

