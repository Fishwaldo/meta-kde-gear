# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kio-extras-${PV}.tar.xz"
SRC_URI[sha256sum] = "5a1cebeef8ced99f22093be40a6081cbc57a750bd813598cb659b4d4c8264809"

