# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/krdc-${PV}.tar.xz"
SRC_URI[sha256sum] = "5d8f2be1ed4f51e58b49ae62c4bfc0ac26246b8a8529c2ac6b32ce84081228c6"

