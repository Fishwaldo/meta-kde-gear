# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/krdc-${PV}.tar.xz"
SRC_URI[sha256sum] = "11f8e54fb57cbdc18f383ba57960ea2c4fab2cd33bf89658ad4bf05552898879"

