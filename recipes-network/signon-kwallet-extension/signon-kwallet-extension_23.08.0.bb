# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/signon-kwallet-extension-${PV}.tar.xz"
SRC_URI[sha256sum] = "a1b879765bdab9fbbb97b7d3e8dacfbd9f90b81d4238966c430862516c4dd743"

