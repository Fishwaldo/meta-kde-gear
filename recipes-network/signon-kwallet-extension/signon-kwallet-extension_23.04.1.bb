# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/signon-kwallet-extension-${PV}.tar.xz"
SRC_URI[sha256sum] = "799ceef1981927633f6bd9c3aaeca397ced6847c822730836673f11620597f0d"

