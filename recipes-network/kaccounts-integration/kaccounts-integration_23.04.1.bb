require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kaccounts-integration-${PV}.tar.xz"
SRC_URI[sha256sum] = "05dcc4729ed492feb67afcc23ce3e3df91de2575d1c7d0be56db70bb31c30e52"
