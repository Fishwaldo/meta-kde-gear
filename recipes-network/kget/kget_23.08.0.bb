# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/release-service/${PV}/src/kget-${PV}.tar.xz"
SRC_URI[sha256sum] = "168ce8fea7e0e66d21eb128c98f81377316e6cff1627e67692e2cb0f2f2bbef0"

