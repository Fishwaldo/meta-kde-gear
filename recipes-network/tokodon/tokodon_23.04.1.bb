# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/tokodon-${PV}.tar.xz"
SRC_URI[sha256sum] = "81e17481308d22327149267853834646b73587f95537bcf7ccf169a7dc0790ec"

