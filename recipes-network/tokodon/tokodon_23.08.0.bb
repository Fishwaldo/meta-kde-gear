# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/tokodon-${PV}.tar.xz"
SRC_URI[sha256sum] = "50c8c6c34d7fdb41312fe132cdeb2a507e55274a879e432f68b1de92b6e98bb7"

