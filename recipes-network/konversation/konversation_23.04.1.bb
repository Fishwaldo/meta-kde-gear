# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/konversation-${PV}.tar.xz"
SRC_URI[sha256sum] = "3750746ebf3a376d80ef0344fd34e7713b50af813d24049d6e9ed15d3203a08c"

