# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/konversation-${PV}.tar.xz"
SRC_URI[sha256sum] = "1d1897c9ee9997da524f41813d1174b59d87bbb5efbae24a1c65227aaf4b54fe"

