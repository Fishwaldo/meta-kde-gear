# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kio-gdrive-${PV}.tar.xz"
SRC_URI[sha256sum] = "a9b3f96b9e3dc6154f33817396ca3d2b2eb40c97901e840f3a3055b8105f2900"

