# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kio-gdrive-${PV}.tar.xz"
SRC_URI[sha256sum] = "9f55404c371cd59e513582b041b8ec3df52663a12723e94303d967efe1e1cfb2"

