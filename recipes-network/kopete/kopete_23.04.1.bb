# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kopete-${PV}.tar.xz"
SRC_URI[sha256sum] = "b93d50cf2c2aa6763392af4031cf5e4ee3027c64bafa0f75997abe0dacf0e6ec"

