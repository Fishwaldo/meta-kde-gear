# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kopete-${PV}.tar.xz"
SRC_URI[sha256sum] = "09399e7645ffbc4b7fa25f96af1d9870eb9d16dab21ece64e4d61fbc467e5e8f"

