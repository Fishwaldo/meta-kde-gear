# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/krfb-${PV}.tar.xz"
SRC_URI[sha256sum] = "c0440fe9109578767b1513f44e165601a64a660f7b546dbcff7477b07cf9b848"

