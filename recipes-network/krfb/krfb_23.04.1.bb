# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/krfb-${PV}.tar.xz"
SRC_URI[sha256sum] = "6f3f9a28ce71c5f3523ad3cca3110a35529ab623e27086bbcac053eb3400192d"

