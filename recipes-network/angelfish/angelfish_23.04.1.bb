require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/angelfish-${PV}.tar.xz"
SRC_URI[sha256sum] = "86cce6d2119f70a078677846f00699cc36342b26e3df00a1a78300108dc2aef4"
