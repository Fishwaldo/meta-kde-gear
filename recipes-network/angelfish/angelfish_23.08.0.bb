# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/angelfish-${PV}.tar.xz"
SRC_URI[sha256sum] = "f2a6656e4675fb59d5f634fc1e4577c1e151c9caa1d20fc7ed0fa92547bcbb03"

