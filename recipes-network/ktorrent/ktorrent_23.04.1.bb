# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktorrent-${PV}.tar.xz"
SRC_URI[sha256sum] = "848fb319796aebf8553b04f9475c5058d7d4e817ccf5e87a3bbe5780403625d8"

