# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/release-service/${PV}/src/ktorrent-${PV}.tar.xz"
SRC_URI[sha256sum] = "190858bd7a3c562a0404e756654b7b947b4541b685f17729bd61ce9423351711"

