# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/neochat-${PV}.tar.xz"
SRC_URI[sha256sum] = "c700bda4e00d87030b8b8f1524f8854f45ccae6d2bd81941a90641e3dfc1a5fa"

