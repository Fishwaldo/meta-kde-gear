# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/neochat-${PV}.tar.xz"
SRC_URI[sha256sum] = "4ead1a9fa308e53173229a744075c59580ed3364bd206a08c07d9db163758bfb"

