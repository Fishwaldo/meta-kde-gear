# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmousetool-${PV}.tar.xz"
SRC_URI[sha256sum] = "c16b08c64edc352b4d32227a3a63a1ddec5282bca95f7b8ea17143265ac232da"

