# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmousetool-${PV}.tar.xz"
SRC_URI[sha256sum] = "6a089c527253f79f27684dc22369d13448a7f15900251628355c4412e057abe3"

