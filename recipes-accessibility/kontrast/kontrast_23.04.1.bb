# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kontrast-${PV}.tar.xz"
SRC_URI[sha256sum] = "fb7a0d2955db1931f32557f08bd600ab3d8ca93aeb72234b828721f667304653"

