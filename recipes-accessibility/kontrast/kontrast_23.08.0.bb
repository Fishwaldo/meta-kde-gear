# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kontrast-${PV}.tar.xz"
SRC_URI[sha256sum] = "aa4b3beac42660e94d4fe59da3f6f88d1b2fd585590246017b578cb1d0141705"

