# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kiten-${PV}.tar.xz"
SRC_URI[sha256sum] = "2ac340aa6f5db6d367afbfaefc0d159768bed36a9016892f17c2f0c8164c1dba"

