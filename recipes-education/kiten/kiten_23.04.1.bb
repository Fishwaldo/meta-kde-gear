# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kiten-${PV}.tar.xz"
SRC_URI[sha256sum] = "0af35d3ebbd1fbba7dbc0a22d2435e370243c5afbd526374dd9ee7d6ada98e89"

