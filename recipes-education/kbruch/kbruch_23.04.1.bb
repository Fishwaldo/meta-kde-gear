# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kbruch-${PV}.tar.xz"
SRC_URI[sha256sum] = "b25ceb8f25d07bbabe2429e7ed6e60bcf56804f5119728131f0907dbb131bced"

