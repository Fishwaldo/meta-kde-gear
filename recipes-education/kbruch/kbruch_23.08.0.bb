# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kbruch-${PV}.tar.xz"
SRC_URI[sha256sum] = "4d6d747c838d10e298d6bf0b73a44ffb78852483686f809ead65e198fc5ff546"

