# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kgeography-${PV}.tar.xz"
SRC_URI[sha256sum] = "c5715b767b303af086d20974154acef61c4c4f3994d54fc24edf5cad957ad681"

