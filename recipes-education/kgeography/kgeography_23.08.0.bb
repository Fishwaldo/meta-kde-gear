# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kgeography-${PV}.tar.xz"
SRC_URI[sha256sum] = "915b1061a0aaa0d3607bbc87336b45e69500e6defcf6d781f5511646eb38e9e7"

