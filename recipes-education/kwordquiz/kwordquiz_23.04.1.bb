# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kwordquiz-${PV}.tar.xz"
SRC_URI[sha256sum] = "b9d2180c5d07d0c050501b11b42ebed331d1eaa6c3eca223339fb34908c2512c"

