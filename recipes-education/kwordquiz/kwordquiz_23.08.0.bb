# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kwordquiz-${PV}.tar.xz"
SRC_URI[sha256sum] = "4fa4a103a3486826e1e29eda35f7365f896d29a25ac646dac88097eb3b82f4d8"

