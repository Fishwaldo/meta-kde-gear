# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktouch-${PV}.tar.xz"
SRC_URI[sha256sum] = "d87ae4bb2885af2ca549e5a993b93a2f45074df3ae30efb09361ba421204a578"

