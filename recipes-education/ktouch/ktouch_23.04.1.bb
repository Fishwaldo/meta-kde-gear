# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktouch-${PV}.tar.xz"
SRC_URI[sha256sum] = "e4a32f3c1e7af3c123d8c18fea8c31883a614dba8f88ec5cc73bd6cd54f35cb5"

