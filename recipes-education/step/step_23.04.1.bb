# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/step-${PV}.tar.xz"
SRC_URI[sha256sum] = "2e495bfa2bda484b28ca83a7f6209070a1c88308d3a515110d208c36c6cc8ebd"

