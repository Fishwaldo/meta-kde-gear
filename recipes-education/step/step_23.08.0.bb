# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/step-${PV}.tar.xz"
SRC_URI[sha256sum] = "1b7b7fe5abd843092884fd5c60afbd244fe87c8d9640a2ab0711fe9f0e2d0b8d"

