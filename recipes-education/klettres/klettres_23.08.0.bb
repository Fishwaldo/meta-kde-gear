# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/klettres-${PV}.tar.xz"
SRC_URI[sha256sum] = "8dca964ea71ccd11c6a611fc919e98a9e265d9c2b394cb105d64d398e8ad16f3"

