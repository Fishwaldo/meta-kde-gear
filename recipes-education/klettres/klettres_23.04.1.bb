# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/klettres-${PV}.tar.xz"
SRC_URI[sha256sum] = "ddebc67ebb3183633d52f31bd2ef5978bf25fc908f7c2ef77a21216a3f47c118"

