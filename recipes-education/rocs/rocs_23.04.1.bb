# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/rocs-${PV}.tar.xz"
SRC_URI[sha256sum] = "4b9f4a19a1450f02ed8f503002b83d687556e9eb65a2ba9284882e3925e45f3c"

