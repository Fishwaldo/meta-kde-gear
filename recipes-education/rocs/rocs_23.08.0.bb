# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/rocs-${PV}.tar.xz"
SRC_URI[sha256sum] = "b8cf105131cfc6f19e06cb1fa4fcd42b510f304f7cd2f2afc28b7fbcd4de0a96"

