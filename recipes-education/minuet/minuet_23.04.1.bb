# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/minuet-${PV}.tar.xz"
SRC_URI[sha256sum] = "48cee2a16053924c6d3124e1586f75fb6722486b06e2b1653b42911534b3461f"

