# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/minuet-${PV}.tar.xz"
SRC_URI[sha256sum] = "0661ded99e9bf461d05be6e0484fbcbd08da20ed0a059549fb6c91ad4c3e8a3c"

