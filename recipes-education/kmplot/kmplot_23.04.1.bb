# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmplot-${PV}.tar.xz"
SRC_URI[sha256sum] = "1a0031a5f73d9d4d3174cd4170b3bdd123a909b685aaefaf84a6ea2940f373f8"

