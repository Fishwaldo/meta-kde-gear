# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmplot-${PV}.tar.xz"
SRC_URI[sha256sum] = "ce9f80ca7cd744397acf3f1f8b1da129c785a74ce43fd5e5d2f213951007c045"

