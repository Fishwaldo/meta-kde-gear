# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kanagram-${PV}.tar.xz"
SRC_URI[sha256sum] = "cd6cd4bb5493e2149ab7363e3b5fe6cb077a8a1ce5cd77863528d68b21050371"

