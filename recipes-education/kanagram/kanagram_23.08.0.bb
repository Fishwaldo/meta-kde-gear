# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kanagram-${PV}.tar.xz"
SRC_URI[sha256sum] = "36d139cd98c6ae1b17580440c76048764e93806bfd5595ce52d9a55ecb93caa3"

