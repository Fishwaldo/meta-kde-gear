# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/analitza-${PV}.tar.xz"
SRC_URI[sha256sum] = "f9328b2fd0ff56f1098715185ee866b3937d70aea39e1d432326f35b9b8f74b0"

