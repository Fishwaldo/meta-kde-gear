# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/analitza-${PV}.tar.xz"
SRC_URI[sha256sum] = "dbc46f560342bce65d0e9cd96693527d72fb9b1c7e9a4805b19007afe7636201"

