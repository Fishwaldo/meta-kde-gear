# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kig-${PV}.tar.xz"
SRC_URI[sha256sum] = "26d06dd2749286d18f11365d1b5b29f93cad66f54202c6d5ba46fcaeba73c5bd"

