# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kig-${PV}.tar.xz"
SRC_URI[sha256sum] = "0eef77f17059477efc58fd468a4a555ab592b0feeefa0f984a5e8d5ed9fe6054"

