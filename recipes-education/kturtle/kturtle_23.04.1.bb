# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kturtle-${PV}.tar.xz"
SRC_URI[sha256sum] = "0f7d6f8c4a901ed383d5d6e547c52505ebf4a7a4527460ce121df5b28029a85d"

