# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kturtle-${PV}.tar.xz"
SRC_URI[sha256sum] = "9b56a1e8688174325b52aea5915a36c49f48fca0aa867deb3fdb767e95719318"

