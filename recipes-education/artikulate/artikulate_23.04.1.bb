# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/artikulate-${PV}.tar.xz"
SRC_URI[sha256sum] = "d1928ca183f29b6e9532959ab525fc34520724c1e40b962d737fa55115f78fbf"

