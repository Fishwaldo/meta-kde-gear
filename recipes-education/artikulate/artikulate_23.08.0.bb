# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/artikulate-${PV}.tar.xz"
SRC_URI[sha256sum] = "095de677000668a624f96d82451941131dac5140bbb5b4ea68d52d02cfeb9ee7"

