# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdeedu-data-${PV}.tar.xz"
SRC_URI[sha256sum] = "af594de5565e2d9446ec26a8af157ae05bcf87126873ca336c86c380171dc39e"

