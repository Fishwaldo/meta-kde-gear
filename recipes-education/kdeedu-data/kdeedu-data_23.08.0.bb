# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdeedu-data-${PV}.tar.xz"
SRC_URI[sha256sum] = "8d007c378f8546f34e8b02a75a9491e3aae6b6dbcdcf12030adb6e150b83428c"

