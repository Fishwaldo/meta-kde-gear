# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kalgebra-${PV}.tar.xz"
SRC_URI[sha256sum] = "39cd5d151f612c3dfc83135f931f51ceafab97bb75f075d7930eb02ab3853f67"

