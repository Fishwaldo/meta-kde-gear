# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kalgebra-${PV}.tar.xz"
SRC_URI[sha256sum] = "46618b82ae770ac153db6a1d18831987c7d235d5b50b076b93159eeded79c118"

