# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/khangman-${PV}.tar.xz"
SRC_URI[sha256sum] = "f2b59b05e53b5f8870bd0642de1b1c1325fd2f70012922e1b8061894df4826c7"

