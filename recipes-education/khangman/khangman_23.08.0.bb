# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/khangman-${PV}.tar.xz"
SRC_URI[sha256sum] = "54b79842b9a5ccacdf918dedef909a0c9f43823d37d57ebba21dfc6082ab5af6"

