# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/parley-${PV}.tar.xz"
SRC_URI[sha256sum] = "1c213b58e73eaece3605e08e9799d0fb08745aa36926f2783d26d80b62ad84a7"

