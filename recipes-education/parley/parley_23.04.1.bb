# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/parley-${PV}.tar.xz"
SRC_URI[sha256sum] = "56e13ed4777aa366e1d880ae77d3ac4a8cb4a17e90a4e8e550f6f840a72add51"

