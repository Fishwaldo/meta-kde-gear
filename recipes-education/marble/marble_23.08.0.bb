# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/marble-${PV}.tar.xz"
SRC_URI[sha256sum] = "a11bf99d09ce87acf3f7c997df5e77a5125582f009cf034df6785fd81af55bb6"

