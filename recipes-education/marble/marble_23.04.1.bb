# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/marble-${PV}.tar.xz"
SRC_URI[sha256sum] = "d41e1793e72ac1fd46d39127a70accbcf738c00fe3adbd1159cb32e47f4294d2"

