# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkeduvocdocument-${PV}.tar.xz"
SRC_URI[sha256sum] = "d637876608d6290b32f3e7d2004cabdf810057bc22c396ac93f3610b1a537245"

