# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkeduvocdocument-${PV}.tar.xz"
SRC_URI[sha256sum] = "ae22ce2ba6521efed99369168e7d1dc5545dd6e25e90fe5c8cae87929906f0af"

