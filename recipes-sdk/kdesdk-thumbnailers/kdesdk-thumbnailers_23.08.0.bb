# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdesdk-thumbnailers-${PV}.tar.xz"
SRC_URI[sha256sum] = "3561efd2f45f02c3b39fdae231cfafb18419f7bf6698336ac9e162b5432eada9"

