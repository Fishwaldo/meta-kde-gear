# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdesdk-thumbnailers-${PV}.tar.xz"
SRC_URI[sha256sum] = "2beece42639084ce036ce08569545622a535b454d054c718ba31c85b2d80e5a2"

