# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcachegrind-${PV}.tar.xz"
SRC_URI[sha256sum] = "7c577d3d2e7115c1461ca50f1b128996719222a19d4d102376420dcc2b510781"

