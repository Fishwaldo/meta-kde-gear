# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcachegrind-${PV}.tar.xz"
SRC_URI[sha256sum] = "91d4679fb19bf1bfa2a3beb23c3f629aba2f0871dff09af144511901a26274ea"

