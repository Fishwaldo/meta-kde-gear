# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/poxml-${PV}.tar.xz"
SRC_URI[sha256sum] = "e234271bc8b030b3f1b196803c1f6128f47e212eca30d8187ca6e45a2cd8509e"

