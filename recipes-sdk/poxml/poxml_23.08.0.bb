# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/poxml-${PV}.tar.xz"
SRC_URI[sha256sum] = "1745079fc047306a3c79f3fa7a9b6c063ad542cce5dc0a5acf4d9709fe021683"

