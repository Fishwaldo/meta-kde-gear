# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kompare-${PV}.tar.xz"
SRC_URI[sha256sum] = "e1cb78eb6054c92e3febd7e32ef54724114ce97a6df91e9197bef671d55870ba"

