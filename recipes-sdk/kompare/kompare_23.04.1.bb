# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kompare-${PV}.tar.xz"
SRC_URI[sha256sum] = "4891eee00ee5a460dc896a9d378a299435eeb554712cf2a4f0c6141b7d9dd16d"

