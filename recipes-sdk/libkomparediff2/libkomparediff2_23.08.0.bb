# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkomparediff2-${PV}.tar.xz"
SRC_URI[sha256sum] = "54c8f30382aa85db97525ac11ad73aff59fbc273eb6161959041fda39e84e5e1"

