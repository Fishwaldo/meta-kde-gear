# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkomparediff2-${PV}.tar.xz"
SRC_URI[sha256sum] = "b0b8c8692cf270a712b410e2345eb963fb53dd935e047e86cd91496215998bf0"

