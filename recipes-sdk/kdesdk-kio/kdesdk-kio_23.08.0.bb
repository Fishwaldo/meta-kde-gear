# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdesdk-kio-${PV}.tar.xz"
SRC_URI[sha256sum] = "08d166f850b5481929f4d78523e4e4047ce34e9f6b2cbb5403e61a5cd7fc959f"

