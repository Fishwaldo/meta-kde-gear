# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdesdk-kio-${PV}.tar.xz"
SRC_URI[sha256sum] = "77668341e0895d04a1c87979e9a3f952ba267d1ababcebc8ca799f1054742ee3"

