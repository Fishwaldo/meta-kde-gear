# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kirigami-gallery-${PV}.tar.xz"
SRC_URI[sha256sum] = "3d8431591c7e63913051af41c81939dce9b0d2b41ea513eb6c4fd3bed58f861a"

