# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kirigami-gallery-${PV}.tar.xz"
SRC_URI[sha256sum] = "ddecd5f6f6adc808933293dd673c322fe961cc2e56b98d54389c6d7cd0fea61b"

