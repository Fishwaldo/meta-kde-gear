# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/cervisia-${PV}.tar.xz"
SRC_URI[sha256sum] = "07eaacdf05c0a6aed022257a3b9719231e53919d491c6f4885799a40b13162e0"

