# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/cervisia-${PV}.tar.xz"
SRC_URI[sha256sum] = "c8c0fb109b176b7085e0db85f55ae0a2440f9358e477c9f22eaee769e94c3b62"

