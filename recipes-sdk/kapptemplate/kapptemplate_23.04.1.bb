# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kapptemplate-${PV}.tar.xz"
SRC_URI[sha256sum] = "e0127e07867cabf03fbd73634594c4a2066dd722ab1a8a9c265f31d72fb748ab"

