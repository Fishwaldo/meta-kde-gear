# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kapptemplate-${PV}.tar.xz"
SRC_URI[sha256sum] = "93a9564589fe03a6b3bdfca6718918ef04a4ee15d7ea1bf58716ac90135c53e4"

