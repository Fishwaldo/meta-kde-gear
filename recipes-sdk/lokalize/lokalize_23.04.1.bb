# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/lokalize-${PV}.tar.xz"
SRC_URI[sha256sum] = "bf95954dd97d7e8ad2b65bf779a1682140a404c90b4173b06ebcb83aea0efca8"

