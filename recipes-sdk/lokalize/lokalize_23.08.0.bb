# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/lokalize-${PV}.tar.xz"
SRC_URI[sha256sum] = "4a733c5b28cdfbd5fb5f8dfa58bfdd42a4ad75fb1c46e1c2c3a6713687a2b08b"

