require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadiconsole-${PV}.tar.xz"
SRC_URI[sha256sum] = "debc1503e8df042b9ea23d8666c3bacc84743d15a446010f18d23aa0e0a7c7ff"
