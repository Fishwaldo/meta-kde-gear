# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkleo-${PV}.tar.xz"
SRC_URI[sha256sum] = "ccaf8b7ea9c16100ea5602be77b4661a582fddb6f14ede4c32ef23582cac0701"

