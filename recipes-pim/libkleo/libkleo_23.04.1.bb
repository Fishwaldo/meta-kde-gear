require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkleo-${PV}.tar.xz"
SRC_URI[sha256sum] = "b51f395cf239020e117382477b5ef1a994f81e2c49978238d26bf685696d8499"
