require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kaddressbook-23.04.0.tar.xz"
SRC_URI[sha256sum] = "3c91736c0d98a5df94031b080d6c2b4efabf16123a533e5dcc98f31d74c0c96c"
