require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kaddressbook-${PV}.tar.xz"
SRC_URI[sha256sum] = "430c079847873fc188f28c205d3ce13796b8de96a7566c2ace929e8049fabfe2"
