# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kaddressbook-${PV}.tar.xz"
SRC_URI[sha256sum] = "21978688b6f4b220323649b8d806f121e49dd56c168746f55e8656df25ff83ab"

