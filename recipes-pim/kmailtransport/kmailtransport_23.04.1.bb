require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmailtransport-${PV}.tar.xz"
SRC_URI[sha256sum] = "72f89c6e699cb2ffeeb9fa66f15c5532a07b9340857ff4b7f7b1c8cabaa2d830"
