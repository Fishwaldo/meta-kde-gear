# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmailtransport-${PV}.tar.xz"
SRC_URI[sha256sum] = "ef0ede439bc25acbd085917e4ac8573535a9b5d51a8b449fa53a5677e5c2ca45"

