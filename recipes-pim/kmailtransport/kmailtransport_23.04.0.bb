require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kmailtransport-23.04.0.tar.xz"
SRC_URI[sha256sum] = "431cd1d663b41b7de08b692a6fa6863c6e9fed5c245410caea48179fb396c6af"
