# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/zanshin-${PV}.tar.xz"
SRC_URI[sha256sum] = "71e5ffcf52fe6693d4b61b8787243c8253073a5884c453343927e7c0f3aa4121"

