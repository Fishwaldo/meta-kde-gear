# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/zanshin-${PV}.tar.xz"
SRC_URI[sha256sum] = "ddd0e10c4db9b5409d5f0326ed179544e4b7ab83bcbb8e6a71d91a7e8fa88407"

