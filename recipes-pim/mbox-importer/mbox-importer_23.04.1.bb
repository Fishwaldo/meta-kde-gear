# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/mbox-importer-${PV}.tar.xz"
SRC_URI[sha256sum] = "cb7b009d2995f361cad9cd75a9265811c72caf12c5b0a4555de7f3974e82f122"

