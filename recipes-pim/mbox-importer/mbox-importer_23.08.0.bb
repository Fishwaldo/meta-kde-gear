# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/mbox-importer-${PV}.tar.xz"
SRC_URI[sha256sum] = "92ee173f5d1a1b0fc8c731529d2d869c7fc8703b0a5d6ef3192ed70c6a2109e3"

