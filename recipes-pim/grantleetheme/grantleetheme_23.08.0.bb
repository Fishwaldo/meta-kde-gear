# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/grantleetheme-${PV}.tar.xz"
SRC_URI[sha256sum] = "fa944bab73881da5dcfc2f55c25766d5511f3a5b6d4eddeedca2c587bf5300d7"

