require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/grantleetheme-${PV}.tar.xz"
SRC_URI[sha256sum] = "bf8a968b382b57b415d3c71a0d614f42018c2f056a4214b54988ab57f00de1e1"
