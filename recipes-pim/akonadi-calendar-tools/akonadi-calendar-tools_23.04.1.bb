require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-calendar-tools-${PV}.tar.xz"
SRC_URI[sha256sum] = "9d5d6790d5f88b36039700855463d041e2fec0a74b987588d4eb8edc0dd38198"
