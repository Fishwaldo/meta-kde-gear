# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-calendar-tools-${PV}.tar.xz"
SRC_URI[sha256sum] = "a473bd326a0b4d8a371f0c4a52d689b3f0b1ce74750a0b22317c19d3995db20a"

