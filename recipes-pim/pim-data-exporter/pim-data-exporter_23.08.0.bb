# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/pim-data-exporter-${PV}.tar.xz"
SRC_URI[sha256sum] = "ae522a0deb7ae1ef7a24948409fd4e4e9e4cb0427a9703097c7d37356dcc360f"

