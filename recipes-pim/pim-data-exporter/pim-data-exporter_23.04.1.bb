# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/pim-data-exporter-${PV}.tar.xz"
SRC_URI[sha256sum] = "b331970a6e27d96ccbe195a855152685fed8e097ac99e9d3edfdd063433d66c4"

