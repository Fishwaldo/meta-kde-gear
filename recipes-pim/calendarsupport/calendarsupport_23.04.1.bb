# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/calendarsupport-${PV}.tar.xz"
SRC_URI[sha256sum] = "22281099b78b2df6f1c183e294b07bf50f576d193ac790ac1550cd325d4195c0"

