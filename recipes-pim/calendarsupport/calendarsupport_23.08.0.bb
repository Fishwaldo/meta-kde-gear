# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/calendarsupport-${PV}.tar.xz"
SRC_URI[sha256sum] = "b9752c407b4280fc26f477eb16f26fe24d10c59865725931f807bdb403ae1233"

