# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdepim-addons-${PV}.tar.xz"
SRC_URI[sha256sum] = "615fbecfb12c57c54b8d853a0be68f337b9c3e380f257fe468d442bddfaf2ea1"

