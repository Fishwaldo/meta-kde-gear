# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdepim-addons-${PV}.tar.xz"
SRC_URI[sha256sum] = "2d8d38e79cb24038461112bb479a761612db1c5544de6b8c67900ca192d4104c"

