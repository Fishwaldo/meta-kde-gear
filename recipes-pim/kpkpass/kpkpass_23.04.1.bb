# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kpkpass-${PV}.tar.xz"
SRC_URI[sha256sum] = "fb9cdc75a43fca6704e66e96c99cd080de797dcf07387da198a8af150dad0e53"

