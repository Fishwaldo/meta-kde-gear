# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kpkpass-${PV}.tar.xz"
SRC_URI[sha256sum] = "9713707e416e3351ec6344e0a428074c1927f5a53b335966b1c95b4cf07f460b"

