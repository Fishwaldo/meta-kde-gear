# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/eventviews-${PV}.tar.xz"
SRC_URI[sha256sum] = "6285105047d11955292aeb7a25ee9e36bc5cbe25811ae62b9802a39a36a3113e"

