# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/eventviews-${PV}.tar.xz"
SRC_URI[sha256sum] = "d2f6099b939c868690295ffc9d852ec108e09cbf1fe5921594f595d444242212"

