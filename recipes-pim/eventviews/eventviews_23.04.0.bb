# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/eventviews-23.04.0.tar.xz"
SRC_URI[sha256sum] = "16ab833f540470366a65fb6b57b46bfc5b272e1dd473df33a7df47497df4430d"

