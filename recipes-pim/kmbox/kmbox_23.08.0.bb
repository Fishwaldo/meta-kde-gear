# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmbox-${PV}.tar.xz"
SRC_URI[sha256sum] = "441bbb3c13cb535a216feb411ffe5925f4ca668a679c3cc1c4260c2bf406baec"

