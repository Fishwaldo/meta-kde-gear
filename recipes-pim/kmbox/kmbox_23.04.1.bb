require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmbox-${PV}.tar.xz"
SRC_URI[sha256sum] = "329930eea85ef68f1cc60f647b3ef1afaf9b6c2fe574911cb4148519ea12b432"
