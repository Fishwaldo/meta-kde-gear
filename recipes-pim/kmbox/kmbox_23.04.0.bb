require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kmbox-23.04.0.tar.xz"
SRC_URI[sha256sum] = "d587f87fb5358e8d7f0495c7e9e6dfea4a4de33671387a71fd4033145c26386b"
