require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kalendar-${PV}.tar.xz"
SRC_URI[sha256sum] = "773876ae51bd6ce6e0011742dcf509b6b1ab34afc0ec9e3f1f2032e56a76aab0"
