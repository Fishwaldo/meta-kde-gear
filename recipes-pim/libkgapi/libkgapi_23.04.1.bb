require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkgapi-${PV}.tar.xz"
SRC_URI[sha256sum] = "dd00c08ff7b8fbff9f280caf0c7bebe268c8e4c24b28f1cb76ba14bc52dcf881"
