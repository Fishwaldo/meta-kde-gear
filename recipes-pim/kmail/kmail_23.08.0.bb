# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmail-${PV}.tar.xz"
SRC_URI[sha256sum] = "a538cd16dcbd343e16318d1834cde2f1b84135ca2be86a9063408b0573fa5714"

