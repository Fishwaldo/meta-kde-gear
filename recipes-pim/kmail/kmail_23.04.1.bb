# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmail-${PV}.tar.xz"
SRC_URI[sha256sum] = "6fb2876385618a371b9ad7877daf3d5c1d9353c9814c07a2c4afff120ba4992f"

