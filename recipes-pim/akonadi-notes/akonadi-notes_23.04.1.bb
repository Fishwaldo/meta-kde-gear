require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-notes-${PV}.tar.xz"
SRC_URI[sha256sum] = "44d27f85264691799ae7bfbeb6385993a44325c8e26b67e57776af91d4b91838"
