require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/akonadi-notes-23.04.0.tar.xz"
SRC_URI[sha256sum] = "c4f64ff89816ae14d8fc93e02ab0971d9beda6ae69dd710443d4efd0d94ff93f"
