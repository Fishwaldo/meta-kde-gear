# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-notes-${PV}.tar.xz"
SRC_URI[sha256sum] = "ac580c77102c91e3b4a56e1f726ee46b4948d71d8b6fa3dbb10411589bbf683d"

