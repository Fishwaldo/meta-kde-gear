# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/mailcommon-${PV}.tar.xz"
SRC_URI[sha256sum] = "a42dcd0b5d5542d971b85d2ae683d902463d8fc4521d6e10b80738c93ac5a976"

