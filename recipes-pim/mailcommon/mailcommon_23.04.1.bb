require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/mailcommon-${PV}.tar.xz"
SRC_URI[sha256sum] = "0da38d564313d4dea7e078ae4509f3c686eb5bb1258cd3ac6b3bf265675fd777"
