# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-contacts-${PV}.tar.xz"
SRC_URI[sha256sum] = "77923b46bde908fa22927ac21eedbeea9948191485d3e2e4a7044bdc5b812707"

