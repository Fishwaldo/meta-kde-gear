require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/akonadi-contacts-23.04.0.tar.xz"
SRC_URI[sha256sum] = "afd816058723d4fda79b61f0f052b24d47b822699695522db21c1a2141d7f83b"
