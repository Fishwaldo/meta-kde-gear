require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-contacts-${PV}.tar.xz"
SRC_URI[sha256sum] = "20b806be770922b3715158e4ec8fab2117948979ada37a56e8bce7577f62a709"
