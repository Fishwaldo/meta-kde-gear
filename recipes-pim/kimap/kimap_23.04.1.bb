require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kimap-${PV}.tar.xz"
SRC_URI[sha256sum] = "0562b18d3a36ff612314bb675a6bb263b18aa614dd05167b4051fdc60f841666"
