# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kimap-${PV}.tar.xz"
SRC_URI[sha256sum] = "8782cac26498155a311b409a4d5fcdc2b662d86ed8494a4d1b23db6ccdebc266"

