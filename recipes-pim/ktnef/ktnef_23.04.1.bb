# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktnef-${PV}.tar.xz"
SRC_URI[sha256sum] = "2b7e4b8530af0f4db42b6ded2d4728fe89d08807206c0fc6bc2033bb2e7c3756"

