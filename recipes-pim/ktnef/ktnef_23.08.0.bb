# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktnef-${PV}.tar.xz"
SRC_URI[sha256sum] = "8186e45771df597c3a69f7ec384420aea27ef5bb451cf6bd48c3bcf257c3cb03"

