require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/merkuro-${PV}.tar.xz"
SRC_URI[sha256sum] = "2aea56404f2b2a88151a81bef4ea2c187a2435cc0828ab5fc7806f914a973977"
