# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/incidenceeditor-${PV}.tar.xz"
SRC_URI[sha256sum] = "9f240eaa281abf8e60251a78cdeb4355b36d9a8dac2e2f0e0b31fbb609bb11d0"

