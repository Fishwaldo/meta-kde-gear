# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/incidenceeditor-${PV}.tar.xz"
SRC_URI[sha256sum] = "f6ba29f4cddd2e536e0c00ecaba5752d452406c175f3bc08068e67fa70313bdc"

