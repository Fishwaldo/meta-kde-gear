require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kpimtextedit-23.04.0.tar.xz"
SRC_URI[sha256sum] = "cc6819004d5e73aae9b3b8f0679b79cf49f1d3b9c9f0451e78bd1ef809319cf1"
