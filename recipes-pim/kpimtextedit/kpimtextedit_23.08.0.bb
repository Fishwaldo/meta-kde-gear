# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kpimtextedit-${PV}.tar.xz"
SRC_URI[sha256sum] = "63367a4a173536a91b7186813aea5b6b42bf88724483e983a5b6c60e9a48b897"

