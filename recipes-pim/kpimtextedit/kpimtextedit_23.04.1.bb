require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kpimtextedit-${PV}.tar.xz"
SRC_URI[sha256sum] = "99f02cb4dd5f60efe7f80d50e2941617920ebd392e9c900511c054b4c0d66aaa"
