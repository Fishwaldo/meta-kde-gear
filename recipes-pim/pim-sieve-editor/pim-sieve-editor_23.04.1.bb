# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/pim-sieve-editor-${PV}.tar.xz"
SRC_URI[sha256sum] = "ec6796f0afb602ad5291afc94a464cf78aef50a49bff63d2631c9c795273750a"

