# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/pim-sieve-editor-${PV}.tar.xz"
SRC_URI[sha256sum] = "5519d96c0b94c0884caec900d5dc6d82e60f89ef19ec191fbad2048a4a02e5c4"

