# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akregator-${PV}.tar.xz"
SRC_URI[sha256sum] = "284b959993a11cb6c6fae8323a6fa0147322b382c533f08236c43fdf5063de50"

