# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-import-wizard-${PV}.tar.xz"
SRC_URI[sha256sum] = "55373b559d233d46820270ceafb3c351821a2940e708ab7ce49154b78b603a07"

