require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-import-wizard-${PV}.tar.xz"
SRC_URI[sha256sum] = "55caa240da816f3f78fa7bd6fa97e4ac83ae6a339c8784e20ae648285639bbf6"
