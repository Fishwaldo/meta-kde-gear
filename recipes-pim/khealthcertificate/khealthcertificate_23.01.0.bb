# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/${PV}/khealthcertificate-${PV}.tar.xz"
SRC_URI[sha256sum] = "755dc2625c4b2ad06266ce19fa7565f87dc3df780d161830db498027477b6aa4"

