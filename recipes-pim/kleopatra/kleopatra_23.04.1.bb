# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kleopatra-${PV}.tar.xz"
SRC_URI[sha256sum] = "ec09a9a575607a3087d53589d71717b6885c23ca88badea1309630ea2fb2f829"

