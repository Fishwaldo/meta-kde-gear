# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kleopatra-${PV}.tar.xz"
SRC_URI[sha256sum] = "b88f20217bd5f1855dda84c5304c015b5cc860a748f9deff28c488c50236255f"

