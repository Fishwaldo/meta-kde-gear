require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkdepim-${PV}.tar.xz"
SRC_URI[sha256sum] = "d0644a0a22c549a1e92cb3ba3648feffc3fceb8de0a8935d2d9d6b6917daae28"

