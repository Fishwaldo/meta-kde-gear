# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkdepim-${PV}.tar.xz"
SRC_URI[sha256sum] = "2038f8477d40837a8c1e6da06c2aaec6914647481db192620295638a32680cee"

