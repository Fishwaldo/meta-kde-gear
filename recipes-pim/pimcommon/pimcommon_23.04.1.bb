require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/pimcommon-${PV}.tar.xz"
SRC_URI[sha256sum] = "53048b27b23bf878fbd78a8488c2a870460d54a1147315b8218f548ce35c2ad3"
