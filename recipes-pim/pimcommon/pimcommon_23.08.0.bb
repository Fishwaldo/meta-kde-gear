# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/pimcommon-${PV}.tar.xz"
SRC_URI[sha256sum] = "bb81856d1bc1bb3e2fd00198f2429e6d0ace04b294b1167a61b386a294f424e0"

