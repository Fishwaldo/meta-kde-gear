require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/pimcommon-23.04.0.tar.xz"
SRC_URI[sha256sum] = "3446344b154fe444848efea27368be6da8e21aca30a9c6b03d9a078ead6681ac"
