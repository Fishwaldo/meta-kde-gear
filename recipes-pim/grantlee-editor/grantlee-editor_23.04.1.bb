# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/grantlee-editor-${PV}.tar.xz"
SRC_URI[sha256sum] = "58457d816d5aa7b90e21739ee9084fa07e5494849543364055b37ce26adad33f"

