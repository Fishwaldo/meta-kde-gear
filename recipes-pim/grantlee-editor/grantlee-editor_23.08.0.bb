# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/grantlee-editor-${PV}.tar.xz"
SRC_URI[sha256sum] = "eb08c3ee3afcf6b4118639571d73b510960b42842e1659b69e2c541faca06d5d"

