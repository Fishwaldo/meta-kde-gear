# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kontact-${PV}.tar.xz"
SRC_URI[sha256sum] = "4ec54585d40ede00a2e5f61c90d858ab755ea1f17d7bcce0f5f9370aab1e83d0"

