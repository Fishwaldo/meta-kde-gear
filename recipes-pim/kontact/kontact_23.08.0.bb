# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kontact-${PV}.tar.xz"
SRC_URI[sha256sum] = "99d9e7844d391a8ec013dc341efbb94ecab156972a1fc91b003db2798dabcd84"

