# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-calendar-${PV}.tar.xz"
SRC_URI[sha256sum] = "6e6a0a2cd7651fc46b7b23c864bc6a5411964648893a403b0f1114285a2efaa8"

