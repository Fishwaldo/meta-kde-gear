require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/akonadi-calendar-23.04.0.tar.xz"
SRC_URI[sha256sum] = "ee58cf76e820af9c51d14121a4b2e4a171c6ef702655aaa111ac96aadb0e6cda"
