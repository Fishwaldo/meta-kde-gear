require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-calendar-${PV}.tar.xz"
SRC_URI[sha256sum] = "8e01b605dee3eb03f89764b6eeeed82eb57c8823437cec3a56be81dd476174f1"
