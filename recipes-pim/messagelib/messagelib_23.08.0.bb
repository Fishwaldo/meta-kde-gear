# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/release-service/${PV}/src/messagelib-${PV}.tar.xz"
SRC_URI[sha256sum] = "5e1af42ebc944b1bb21c9574331ef39a755f27d51b5a127b31a55a104dd51fb7"

