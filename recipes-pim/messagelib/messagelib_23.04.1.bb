require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/messagelib-${PV}.tar.xz"
SRC_URI[sha256sum] = "2b7e01ccf1f432a6c8e67d18895bd92dd159b60e25a93017a596477187c8fbb1"
