# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcalutils-${PV}.tar.xz"
SRC_URI[sha256sum] = "fe49f59c44383d3fa0df69fa444d5283749beec7a59f0db1dac1e20b480317f3"

