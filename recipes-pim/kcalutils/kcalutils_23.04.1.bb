require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcalutils-${PV}.tar.xz"
SRC_URI[sha256sum] = "c6af12b9e142e1774c3365738bbf962381c4d2c3ce1b04d028d3dcee9a4ec02d"

