require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmime-${PV}.tar.xz"
SRC_URI[sha256sum] = "a0efb8bba7e12ea1766a3817b644097b48563f1e6c485a8f7a7dcac411fdbbd6"
