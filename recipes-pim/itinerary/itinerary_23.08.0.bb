# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/itinerary-${PV}.tar.xz"
SRC_URI[sha256sum] = "c598f620f4a9fc2107664537cf86bc85c6ec564c40ce30ac4fce342f4eab0779"

