# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/itinerary-${PV}.tar.xz"
SRC_URI[sha256sum] = "49f28144f16995faaa30a293301c92d534e8332153a3590b73009dc476590ad0"

