require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/knotes-23.04.0.tar.xz"
SRC_URI[sha256sum] = "680370dc3232eed63397d6cba2f5c9a0b6623ff13266ae4182da9c2aaed41c91"
