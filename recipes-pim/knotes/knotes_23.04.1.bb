require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/knotes-${PV}.tar.xz"
SRC_URI[sha256sum] = "f47f6efd252a795eeefe07d4687929350aeb421e1ea36e9a2e2b36082cc56064"
