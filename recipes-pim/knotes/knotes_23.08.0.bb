# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/knotes-${PV}.tar.xz"
SRC_URI[sha256sum] = "18b3bc8eb64f431e2dc87f5d5db571a629fb127f21e54a65fd322bc40ef9bb0e"

