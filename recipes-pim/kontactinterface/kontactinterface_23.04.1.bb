require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kontactinterface-${PV}.tar.xz"
SRC_URI[sha256sum] = "82f8322de306539ec2eed958b6cc3ebc9a102def9201d52a7b22e8e0a8977dd0"
