# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kontactinterface-${PV}.tar.xz"
SRC_URI[sha256sum] = "e3768f63b090098061445e58379283002fec1e7a8ca0e1c5c3ad7e0888609ee0"

