# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksmtp-${PV}.tar.xz"
SRC_URI[sha256sum] = "b9aa0c661799ced80c8c6bc10c83882698861f3b68f8b5eb222124b8f20fd44d"

