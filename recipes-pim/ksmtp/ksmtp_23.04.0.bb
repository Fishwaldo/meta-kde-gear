require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/ksmtp-23.04.0.tar.xz"
SRC_URI[sha256sum] = "a0fa8bfc5ec158b2cfcabd025e93e381659b39da1b03678a82ef74f34678fb53"
