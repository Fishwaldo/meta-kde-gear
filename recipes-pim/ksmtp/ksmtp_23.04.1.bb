require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksmtp-${PV}.tar.xz"
SRC_URI[sha256sum] = "985087768e4303a658b512c7cf33b7c888db8ea8a8219ba78f1e5aa6ca1dbcf4"
