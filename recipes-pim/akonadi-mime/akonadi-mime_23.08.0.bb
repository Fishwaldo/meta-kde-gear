# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-mime-${PV}.tar.xz"
SRC_URI[sha256sum] = "8aef15168ee4fa31de2a217842373d3581fc7fb790f15abe17eb6628f0f37351"

