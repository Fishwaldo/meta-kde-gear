require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/akonadi-mime-23.04.0.tar.xz"
SRC_URI[sha256sum] = "a91275c5ce277eefc9da76430c2228cdea90ffee0cb523432fcccb01c695b780"
