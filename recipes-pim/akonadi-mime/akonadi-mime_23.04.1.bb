require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-mime-${PV}.tar.xz"
SRC_URI[sha256sum] = "cc4b76ae076e7e2ca732e882cba6a383749e2d89e0e0e4e5cf24b1cec6b485f9"
