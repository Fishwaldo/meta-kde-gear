require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/libgravatar-23.04.0.tar.xz"
SRC_URI[sha256sum] = "6891bce0ebeeda6676f938a296c020b42ed192463986959687ad55c298e6cf24"
