# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libgravatar-${PV}.tar.xz"
SRC_URI[sha256sum] = "4388480392a31b3dbb1d09b428eec0c76865609c3d2fd6c476b97dae9ea414ed"

