require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libgravatar-${PV}.tar.xz"
SRC_URI[sha256sum] = "9f1107fa096e1db1c017ac0fc2172c508c8a7bde6819cd3a8f320f154fd67c9d"
