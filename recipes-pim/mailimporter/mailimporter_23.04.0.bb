require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/mailimporter-23.04.0.tar.xz"
SRC_URI[sha256sum] = "52ad8927a1b1f9b155824a26dc7307c04d870b369afa7c1dd0f2736a100402cc"
