# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/mailimporter-${PV}.tar.xz"
SRC_URI[sha256sum] = "151c800013aab48f9d5fad68ed6454ef5b0dc2020612dc9681aec3e7f18aa302"

