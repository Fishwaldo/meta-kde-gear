require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/mailimporter-${PV}.tar.xz"
SRC_URI[sha256sum] = "68693cab35cf5555e1ddabf1802e974d00ac6b2709f34d5887b3ec4fffa3175c"
