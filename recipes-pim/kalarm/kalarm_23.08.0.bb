# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kalarm-${PV}.tar.xz"
SRC_URI[sha256sum] = "deaaa46d7116160491aa33d19174ff1102faf1c40d8991d3db07ebf18ab4f071"

