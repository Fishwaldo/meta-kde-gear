require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kalarm-${PV}.tar.xz"
SRC_URI[sha256sum] = "33046b8694c90e5e7f88feacf02bd68a4d44078660011a66793fca82788c7fea"

