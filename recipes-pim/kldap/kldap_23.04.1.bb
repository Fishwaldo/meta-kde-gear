require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kldap-${PV}.tar.xz"
SRC_URI[sha256sum] = "008862023f998eda519ce359629e17ca5f75a851f5c60f207a35adf0d3ab64ce"
