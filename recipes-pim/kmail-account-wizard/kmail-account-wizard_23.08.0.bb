# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmail-account-wizard-${PV}.tar.xz"
SRC_URI[sha256sum] = "ab09f8dba8e2a428649d0966e7e164c73d5ba28cc90f7420bea954503bc2c093"

