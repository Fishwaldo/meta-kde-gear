# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmail-account-wizard-${PV}.tar.xz"
SRC_URI[sha256sum] = "3e405eac2c1a2b0c08907ef1724c7e4c67bec2f16e178f862ffa34e1fbe586bc"

