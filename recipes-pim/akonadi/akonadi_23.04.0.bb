require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/akonadi-23.04.0.tar.xz"
SRC_URI[sha256sum] = "e528c3d737c742b2e359345b71f18f65d7973761714716d64b58d35e11094ece"
