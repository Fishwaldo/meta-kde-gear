# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/release-service/${PV}/src/akonadi-${PV}.tar.xz"
SRC_URI[sha256sum] = "0298f8231337a393eb93408c9e98577b07ef25307be7ddc9759c775c257761e3"

