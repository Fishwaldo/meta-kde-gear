# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdepim-runtime-${PV}.tar.xz"
SRC_URI[sha256sum] = "91e2b4ee4552e442da994d14cdd35bc6bca8a4487751d9815852d7fdf1d2229a"

