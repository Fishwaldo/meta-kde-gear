require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdepim-runtime-${PV}.tar.xz"
SRC_URI[sha256sum] = "6ecb39a4235155471c58971b4ad79601bd16c454183b5a435f782592c0797949"
