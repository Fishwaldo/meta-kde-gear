# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/korganizer-${PV}.tar.xz"
SRC_URI[sha256sum] = "46c5353f0fecc21090b4a4ce5d0125ea5f8a7c65f1499d5a3db45af81e6a1bea"

