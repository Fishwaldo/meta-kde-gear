# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/korganizer-${PV}.tar.xz"
SRC_URI[sha256sum] = "8892adc212180c45897d563cfe5c1914d773776577a022b2f475d903901c41a0"

