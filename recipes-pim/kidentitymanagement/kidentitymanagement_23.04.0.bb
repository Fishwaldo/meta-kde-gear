require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kidentitymanagement-23.04.0.tar.xz"
SRC_URI[sha256sum] = "59a86d0fd424dead29f9c3a82c500830c7efa4a4e499e1a31e21e27480fbf098"
