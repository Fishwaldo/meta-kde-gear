# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kidentitymanagement-${PV}.tar.xz"
SRC_URI[sha256sum] = "26e22b9cc1a3c68e1b057dca885912debc9083dc629169451d47f128985d1682"

