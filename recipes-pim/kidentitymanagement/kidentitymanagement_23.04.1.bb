require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kidentitymanagement-${PV}.tar.xz"
SRC_URI[sha256sum] = "e4e6a8076e63564b768dac1684a021afdac6f044008ae40b83101ab14c18e23a"
