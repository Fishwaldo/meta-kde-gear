# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kitinerary-${PV}.tar.xz"
SRC_URI[sha256sum] = "ffd6abea8da93ae52cb4ebe987b7136dbcd3c15ea099e728959ee62f031f253f"

