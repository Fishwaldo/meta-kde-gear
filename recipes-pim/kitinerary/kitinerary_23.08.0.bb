# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kitinerary-${PV}.tar.xz"
SRC_URI[sha256sum] = "392c8c2a1719da9bb5b32b03bdf90fe9e5405a1735bb17dfbb0beeec4985fed4"

