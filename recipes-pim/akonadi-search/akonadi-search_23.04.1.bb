require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-search-${PV}.tar.xz"
SRC_URI[sha256sum] = "c8349ed345a9b9762066d1108fbfac1ae0689b16273836cbc1b602ff18d49c51"
