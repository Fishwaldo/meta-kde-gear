# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/akonadi-search-${PV}.tar.xz"
SRC_URI[sha256sum] = "a9d07c25e7cad492dcf303592acabf3d3cdf414bea7d7916ccea832454316bef"

