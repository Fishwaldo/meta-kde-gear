require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/akonadi-search-23.04.0.tar.xz"
SRC_URI[sha256sum] = "46d1893902ec874251b659b256e8b6e63b68de3862988d998e5307022c166fa1"
