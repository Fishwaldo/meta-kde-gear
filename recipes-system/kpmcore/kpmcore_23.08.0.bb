# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kpmcore-${PV}.tar.xz"
SRC_URI[sha256sum] = "8d327ac4761a00f75a6f18e57f4d2f30ab464067141df3ef193b9c841c679387"

