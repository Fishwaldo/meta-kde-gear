# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kpmcore-${PV}.tar.xz"
SRC_URI[sha256sum] = "34522af0267062fa6a0ce3982e506aa067607cd3ecc9fd79164077753a03081f"

