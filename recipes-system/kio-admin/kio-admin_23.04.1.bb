# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kio-admin-${PV}.tar.xz"
SRC_URI[sha256sum] = "dd6c3872fb5dbda5f9cae3a78e5af005883b3eb92df022e1d28234d6a2a06c95"

