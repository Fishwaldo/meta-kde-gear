# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kio-admin-${PV}.tar.xz"
SRC_URI[sha256sum] = "ec068ceedbe2a2b5a414fb6ebcb49d37fae2f0552ab6cac1e1ec1d045222f494"

