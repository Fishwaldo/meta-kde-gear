# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcron-${PV}.tar.xz"
SRC_URI[sha256sum] = "20a663e5a934d9893aefe255a43a6898c6eee02a74e3ffcca41c5b53ccb05f59"

