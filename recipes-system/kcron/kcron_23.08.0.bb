# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcron-${PV}.tar.xz"
SRC_URI[sha256sum] = "90ea69d9e9abe0d0d742db310f6e59f1db1f61301efb8be7b74d455b8f7a3ff9"

