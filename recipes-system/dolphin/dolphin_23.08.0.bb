# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/dolphin-${PV}.tar.xz"
SRC_URI[sha256sum] = "4ab0f3ee83c0c62f7346031780d46a57d4002f6585c2de3fadfa6708e4ff59de"

