require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/dolphin-${PV}.tar.xz"
SRC_URI[sha256sum] = "3813d0fb06d62dfa049e716654ca361f83a689dd1434b4ba335f5d271d3605dd"
