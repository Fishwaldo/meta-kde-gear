require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/dolphin-23.04.0.tar.xz"
SRC_URI[sha256sum] = "cd49268a3b0309253587d424fbdffe25b26c951df7e6932a42f48cf34b006c50"
