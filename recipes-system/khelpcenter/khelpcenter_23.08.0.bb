# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/khelpcenter-${PV}.tar.xz"
SRC_URI[sha256sum] = "96715e06fc2f491fa447965bbd319cf5ca1f546dba7a5edce14a34d619243ebc"

