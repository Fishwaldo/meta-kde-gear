# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/khelpcenter-${PV}.tar.xz"
SRC_URI[sha256sum] = "ff0dc1e5fcd8158521d8db78d9cc770ab11112a6e6976fc8ebbba72e4b69c895"

