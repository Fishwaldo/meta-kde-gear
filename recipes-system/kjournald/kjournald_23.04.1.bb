require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kjournald-${PV}.tar.xz"
SRC_URI[sha256sum] = "cb2bfd1e112cea57a742a1b4667422d785e4479b16b23027c87a6d35a9b37956"
