# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kjournald-${PV}.tar.xz"
SRC_URI[sha256sum] = "91b41d72c6753ffe926ce9d0ced140619b0870c7fe37e3ad6937d2fe4691aca6"

