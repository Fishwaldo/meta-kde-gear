# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/dolphin-plugins-${PV}.tar.xz"
SRC_URI[sha256sum] = "c443084976ac84b2e29e1ada97f526da9cb924220f2b3fddb0558bdfb1243fde"

