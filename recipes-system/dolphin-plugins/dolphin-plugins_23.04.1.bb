require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/dolphin-plugins-${PV}.tar.xz"
SRC_URI[sha256sum] = "5922605d28d0bcda37caafcbcb6d4edf866c4d4911ec6c7c513cc12ed03cddb5"
