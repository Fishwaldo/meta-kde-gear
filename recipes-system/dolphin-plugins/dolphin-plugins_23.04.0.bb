require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/dolphin-plugins-23.04.0.tar.xz"
SRC_URI[sha256sum] = "68a4d8129c6740c487c77a8bd1025e1a3a75646d9a3303b44551d9fccfaed0d6"
