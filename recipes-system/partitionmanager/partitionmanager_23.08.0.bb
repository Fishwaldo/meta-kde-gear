# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/partitionmanager-${PV}.tar.xz"
SRC_URI[sha256sum] = "7c7ce059f7f4b511aaf2de15fcb3eb3e219b651d872356872e900256879af206"

