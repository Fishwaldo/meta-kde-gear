# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/partitionmanager-${PV}.tar.xz"
SRC_URI[sha256sum] = "88c7fafd03892034ca1c0b028377b2e065f4407c2b625d8b7025b166ca25325f"

