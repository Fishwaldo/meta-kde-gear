# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kde-inotify-survey-${PV}.tar.xz"
SRC_URI[sha256sum] = "0e0b90a45aa9aeb76dfa80fd2324c9c88e1c0a6b47a8c7ea222773b1d016bdd4"

