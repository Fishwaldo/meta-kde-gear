# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kde-inotify-survey-${PV}.tar.xz"
SRC_URI[sha256sum] = "38c26646f6e6afb50a8d23954d435725b05054897d7136e4a8659e9517cd88c1"

