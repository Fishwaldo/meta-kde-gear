require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/ksystemlog-23.04.0.tar.xz"
SRC_URI[sha256sum] = "0cf79c529641a087c83a3f6249ec1b9a493c5a28d954478ca8ddd5c16e8e7f42"
