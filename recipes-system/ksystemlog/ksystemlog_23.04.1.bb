require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksystemlog-${PV}.tar.xz"
SRC_URI[sha256sum] = "15abd24fb8648dd3e6787eac039ece5146af7ea602b27a512d968547a703f7ca"
