# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksystemlog-${PV}.tar.xz"
SRC_URI[sha256sum] = "7d48f37adaf61c148527400ca0fbd45206e298e2716075b4b1871e712fb30c4d"

