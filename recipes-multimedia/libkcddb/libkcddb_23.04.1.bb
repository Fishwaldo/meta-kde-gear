# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkcddb-${PV}.tar.xz"
SRC_URI[sha256sum] = "093afa1af67284e26e1f7df5f630d9c89d7d85f6234f218e91dcf72e9306e242"

