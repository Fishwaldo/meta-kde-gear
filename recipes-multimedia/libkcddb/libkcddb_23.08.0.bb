# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkcddb-${PV}.tar.xz"
SRC_URI[sha256sum] = "643f23d2f950db22fd4ee98b6a92d9d63c7906ea3f68bdbfd1a8f8ea70f1715e"

