# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/release-service/${PV}/src/audiotube-${PV}.tar.xz"
SRC_URI[sha256sum] = "1b6cadf58e6286c67f0682f2eb5dfad43c25ad738a4bde04a55505ea316006f8"

