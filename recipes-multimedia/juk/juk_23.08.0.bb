# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/juk-${PV}.tar.xz"
SRC_URI[sha256sum] = "81314b54a7afcd40cb198e01d98674904b329d4accae2ac1b296c81d44beb711"

