# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/juk-${PV}.tar.xz"
SRC_URI[sha256sum] = "0389d5710c0579cb95a3727b1e0c76caa037042d5818133f4ea1f2288f9b68fc"

