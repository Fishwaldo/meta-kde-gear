# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kamoso-${PV}.tar.xz"
SRC_URI[sha256sum] = "23abf7ad3b4fb9ee76de173f2c7b3ff2b841e9988e574f9efa065b0cb5b21c1a"

