# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kamoso-${PV}.tar.xz"
SRC_URI[sha256sum] = "b29c853357d0fd7383e454fe7eb4b2293b5aa4824926193e660019dff57ffbc7"

