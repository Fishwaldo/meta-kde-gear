# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/dragon-23.04.0.tar.xz"
SRC_URI[sha256sum] = "c4c5c3d78be99c23efbf274ab45ee84f175ac494e78f9a18e2c1c1e2c9c9a9bb"

