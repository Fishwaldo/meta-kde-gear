# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/dragon-${PV}.tar.xz"
SRC_URI[sha256sum] = "1758e39c991adfa1961a25d292d16020c80fd227db29f6f3b257274241e4b9a0"

