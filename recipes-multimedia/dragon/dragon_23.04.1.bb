# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/dragon-${PV}.tar.xz"
SRC_URI[sha256sum] = "7ca45ff533d56f6f4407c55e0ce7923d3dd9419b1bde1f71eacd943a71afc8f6"

