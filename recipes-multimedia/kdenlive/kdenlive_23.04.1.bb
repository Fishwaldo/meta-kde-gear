# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdenlive-${PV}.tar.xz"
SRC_URI[sha256sum] = "957cf1d00017e850690dd17ee1856ab91eb455b4704360a580d6091798e7d04b"

