# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdenlive-${PV}.tar.xz"
SRC_URI[sha256sum] = "5f63f6cc1d7f7578014ef0fdb3f20e85254f05d7066911329ce568b967e4d207"

