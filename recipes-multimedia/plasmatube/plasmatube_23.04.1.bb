# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/plasmatube-${PV}.tar.xz"
SRC_URI[sha256sum] = "02d6d9e6224b013d64074ed33392ded5b353686001eeb2f7bb470d5f1348c930"

