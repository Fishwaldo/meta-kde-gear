# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/plasmatube-${PV}.tar.xz"
SRC_URI[sha256sum] = "acd42208ad618567e56ee1a4c92f72631de413ce8c561396ec6891f174fd1dcd"

