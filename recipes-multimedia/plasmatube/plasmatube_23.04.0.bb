# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/plasmatube-23.04.0.tar.xz"
SRC_URI[sha256sum] = "983e5846a8a5b502ac8d98edf3d76313102433040baa302635873879f6a35b7e"

