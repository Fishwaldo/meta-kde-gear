# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/elisa-23.04.0.tar.xz"
SRC_URI[sha256sum] = "a086572cd0f721834a071a8748e7c1cc76ae01102f287a355a36507157784d63"

