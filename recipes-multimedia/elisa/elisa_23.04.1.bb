# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/elisa-${PV}.tar.xz"
SRC_URI[sha256sum] = "03ab298e83a4daf17acbe8e046516d689471a47260ffb29dca43d47f0a58533a"

