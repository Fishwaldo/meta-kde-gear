# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/elisa-${PV}.tar.xz"
SRC_URI[sha256sum] = "64b2799c2a7a2ece4f95bc702da47d4639fd0d61ca89159567fb0ece1c646da6"

