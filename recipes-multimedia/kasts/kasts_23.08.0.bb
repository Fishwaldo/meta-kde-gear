# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kasts-${PV}.tar.xz"
SRC_URI[sha256sum] = "56427ad9853a6a309245c5425d54b14dea785c6d3364d459e55d484e0bca5e69"

