# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kasts-${PV}.tar.xz"
SRC_URI[sha256sum] = "d5108fe7cd2450de0348c138f7527e9a31557383d6456335321fb9bd9eac0746"

