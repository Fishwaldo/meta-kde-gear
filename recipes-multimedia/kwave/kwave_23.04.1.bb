# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kwave-${PV}.tar.xz"
SRC_URI[sha256sum] = "dd8887ec9cc1f0e832bdeb941fa05a388bd70b809a89fa95c6485372b38faea7"

