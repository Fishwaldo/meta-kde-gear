# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kwave-${PV}.tar.xz"
SRC_URI[sha256sum] = "c403dba9b19540037b2a5e158dcb030f3115789c36564affde6c289f30434728"

