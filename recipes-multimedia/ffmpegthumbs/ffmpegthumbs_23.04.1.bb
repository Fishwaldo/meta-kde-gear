# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ffmpegthumbs-${PV}.tar.xz"
SRC_URI[sha256sum] = "d82573a0993b68406e57e28395d59dd719fca0fb20af383df0af34245a45ea2f"

