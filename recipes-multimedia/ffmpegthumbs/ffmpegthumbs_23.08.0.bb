# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ffmpegthumbs-${PV}.tar.xz"
SRC_URI[sha256sum] = "d0e25a90109416636d50a015e2d91c3745bb7cfe1fc2d80f124f05914be5beed"

