# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/k3b-${PV}.tar.xz"
SRC_URI[sha256sum] = "38f1695d6971e48ae94a4cfa7cfd2d6f5fe875a3d28e66078856de8c375b9968"

