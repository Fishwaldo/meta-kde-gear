# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/k3b-${PV}.tar.xz"
SRC_URI[sha256sum] = "e643feca11d5e6e43b05e00359aee5e01920e25b04ff0e5a126b98395ca77cff"

