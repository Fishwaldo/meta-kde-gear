# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/release-service/${PV}/src/kmix-${PV}.tar.xz"
SRC_URI[sha256sum] = "13dd62562fbf3ebf45b6ce420c8a3b86e22bcb15e58d8625766d0f0a5ae77204"

