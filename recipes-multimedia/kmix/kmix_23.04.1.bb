# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmix-${PV}.tar.xz"
SRC_URI[sha256sum] = "92c8900cb54c5761014b8405bd31a66a486e146e0ca146b93c692eeb3db154dd"

