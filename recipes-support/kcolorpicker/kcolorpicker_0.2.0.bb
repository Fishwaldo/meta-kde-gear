require ${PN}.inc
SRC_URI = "git://github.com/ksnip/kColorPicker.git;protocol=https;branch=master"
SRCREV = "15e16374e51153006d3400cb88066d5272698743"