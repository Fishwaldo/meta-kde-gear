require ${PN}.inc
SRC_URI = "http://oligarchy.co.uk/xapian/1.4.21/xapian-core-1.4.21.tar.xz \
           file://0001-Fix-paths.patch \
           "
SRC_URI[sha256sum] = "80f86034d2fb55900795481dfae681bfaa10efbe818abad3622cdc0c55e06f88"