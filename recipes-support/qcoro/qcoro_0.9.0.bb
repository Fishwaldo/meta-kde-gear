require ${PN}.inc
SRC_URI = "git://github.com/danvratil/qcoro.git;protocol=https;branch=main"
SRCREV = "e66e8882acdea951cd379045167fc9be30564942"