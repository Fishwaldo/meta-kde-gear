require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/ktextaddons/ktextaddons-1.2.1.tar.xz"
SRC_URI[sha256sum] = "3df9a7a041765d6ef12c45f63af5ee21840bb9b66cfccf223c5a0e6f39e4d2c8"