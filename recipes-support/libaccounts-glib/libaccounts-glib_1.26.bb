require ${PN}.inc
SRC_URI = "git://gitlab.com/accounts-sso/libaccounts-glib.git;protocol=https;branch=master"
SRCREV = "d31d74997c8524cac862a2c5f0cd902f99a39fc6"
