require ${PN}.inc
SRC_URI = "git://github.com/ksnip/kImageAnnotator.git;protocol=https;branch=master"
SRCREV = "997fd557b96ea238e27a15f11b0acf338cfe7db4"