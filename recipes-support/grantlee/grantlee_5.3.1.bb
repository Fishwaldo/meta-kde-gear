require ${PN}.inc
SRC_URI = "git://github.com/steveire/grantlee.git;protocol=https;branch=master"
SRCREV = "20d415b56d7c9880644c99efd8fbbdf0951cc499"