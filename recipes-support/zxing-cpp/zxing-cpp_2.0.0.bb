require ${PN}.inc
SRC_URI = "git://github.com/zxing-cpp/zxing-cpp.git;protocol=https;branch=master"
SRCREV="bdb857efae30f5f2abfcf3d626bf1156dc055bae"