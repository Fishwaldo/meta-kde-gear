require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdebugsettings-${PV}.tar.xz"
SRC_URI[sha256sum] = "19c681cecef4caecbd8d9f56526015e72dc073ca6b66553639287a7465fef8a2"
