# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdebugsettings-${PV}.tar.xz"
SRC_URI[sha256sum] = "8d588a379025fe4165760d8ac959a89cecf0141bdee8424d715ecb52ac4310a9"

