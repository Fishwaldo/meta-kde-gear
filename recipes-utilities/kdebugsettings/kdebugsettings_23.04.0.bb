require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kdebugsettings-23.04.0.tar.xz"
SRC_URI[sha256sum] = "fe151d8be7827b40a0ef81eeaab9ec1fc4244aaae90074b3b8098450a9c4cc6b"
