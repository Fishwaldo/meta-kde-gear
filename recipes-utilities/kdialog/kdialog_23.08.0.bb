# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdialog-${PV}.tar.xz"
SRC_URI[sha256sum] = "1650943f3c21a6213e4db347ca5b29d8278b2842d9a0f6108f629c1d408b95c0"

