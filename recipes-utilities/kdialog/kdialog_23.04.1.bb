# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdialog-${PV}.tar.xz"
SRC_URI[sha256sum] = "88d7ee1bae33bff1769601ab50fd0cc4f99c61576c3bdaa06e9db85652afd73f"

