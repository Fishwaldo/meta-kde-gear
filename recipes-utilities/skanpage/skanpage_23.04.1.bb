# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/skanpage-${PV}.tar.xz"
SRC_URI[sha256sum] = "116abbf8bc6260a3803f293e14b113d00675fca104368ba0e7892547841585fd"

