# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/skanpage-${PV}.tar.xz"
SRC_URI[sha256sum] = "01ae2e721384150b67c0c042189de1781d06aa4bb86bbd309d519feb41b8f2f1"

