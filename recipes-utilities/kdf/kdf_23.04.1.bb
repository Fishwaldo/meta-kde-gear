# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdf-${PV}.tar.xz"
SRC_URI[sha256sum] = "e99838463d2c46b9c18588d55583828032a057f68a846163b5842fadfe8f83ac"

