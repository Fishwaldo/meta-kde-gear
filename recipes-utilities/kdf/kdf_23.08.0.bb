# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdf-${PV}.tar.xz"
SRC_URI[sha256sum] = "b8656734c2d21e00ab865c5c1b0cbee84c4539d731db8dafc0de21bd8e72aff4"

