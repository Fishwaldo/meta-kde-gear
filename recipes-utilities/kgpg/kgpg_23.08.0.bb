# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kgpg-${PV}.tar.xz"
SRC_URI[sha256sum] = "6a84438a671a67797963ff125b9dee87917cdfda127ab8521cdb84bb8fd91893"

