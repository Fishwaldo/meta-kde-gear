# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kgpg-${PV}.tar.xz"
SRC_URI[sha256sum] = "71008975003617f2e8da169c296717acc46dc1533f2d529cf8fe1c8d30ea680a"

