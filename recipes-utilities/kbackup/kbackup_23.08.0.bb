# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kbackup-${PV}.tar.xz"
SRC_URI[sha256sum] = "cafa01cd57951ab91907f1ec1bd45adbdf2bb3727585cdfb231a23a845ce2145"

