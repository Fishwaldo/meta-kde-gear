# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kbackup-${PV}.tar.xz"
SRC_URI[sha256sum] = "c8a6f329a42dd3efd75d0fba910f0dcaecdf956ee95b81fa9ea086552444eb23"

