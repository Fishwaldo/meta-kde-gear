# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kongress-${PV}.tar.xz"
SRC_URI[sha256sum] = "93ba12af76e38624d45898a73c9a271264c72e3172e3b23aef92bcf4b7c2e39c"

