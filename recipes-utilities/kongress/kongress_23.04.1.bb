# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kongress-${PV}.tar.xz"
SRC_URI[sha256sum] = "32ba3c274ec0e31e63210eda98ca6ae1322d097d4aef941517d8adcdc9ef8636"

