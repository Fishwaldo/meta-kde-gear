require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcalc-${PV}.tar.xz"
SRC_URI[sha256sum] = "9e4a356b5e37a10d678fc5c7c6b13590d5850f64065bc97da64ecf9f16803633"
