# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcalc-${PV}.tar.xz"
SRC_URI[sha256sum] = "ded207841f1dbb8a8373d94c7a014de17b893c06553fe9de9a871154c53eece0"

