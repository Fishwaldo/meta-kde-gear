# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kwalletmanager-${PV}.tar.xz"
SRC_URI[sha256sum] = "d8e1f2137b541d4aa88e57d30ee77223f47c0e9fa63a308941287bb81012c341"

