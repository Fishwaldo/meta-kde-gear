require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kwalletmanager-${PV}.tar.xz"
SRC_URI[sha256sum] = "7008de7a475c9f9681e961a5038b96b5c96e4cedfd3dc701758c64f1bc233c4b"
