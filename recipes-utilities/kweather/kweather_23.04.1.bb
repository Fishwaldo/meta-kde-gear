# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kweather-${PV}.tar.xz"
SRC_URI[sha256sum] = "2a3bd85616d7333ab2369a108d1ea881a00b4862c6b3a70bdb82fb2e1d9826dc"

