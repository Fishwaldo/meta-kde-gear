# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kweather-${PV}.tar.xz"
SRC_URI[sha256sum] = "058312707300f29dfd932774c7cdd3aad7d27c5dcda0f710dd1ddd2969bdd503"

