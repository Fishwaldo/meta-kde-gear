# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/filelight-${PV}.tar.xz"
SRC_URI[sha256sum] = "2c16cff975b8d292061524c28700c641da7ce129e9937c984af5ef288bb776e2"

