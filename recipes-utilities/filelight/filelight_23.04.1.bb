# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/filelight-${PV}.tar.xz"
SRC_URI[sha256sum] = "78c009da713d6fe9f5866f26c0c162d751d5b182a0dee4b1840af987e15ae348"

