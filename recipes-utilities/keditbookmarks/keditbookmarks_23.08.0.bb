# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/keditbookmarks-${PV}.tar.xz"
SRC_URI[sha256sum] = "c649ce47c28cc24f5a683b9a692ad1c67158c35c0f7b4cc17ddb0e77714071bb"

