# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/keditbookmarks-${PV}.tar.xz"
SRC_URI[sha256sum] = "cd087c0623bd910ea74741bd946813400364cdd85d3c4361a3e0c460a3758231"

