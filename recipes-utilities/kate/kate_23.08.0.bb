# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kate-${PV}.tar.xz"
SRC_URI[sha256sum] = "3e930d2cfe5cd1a7237ddcd29a42d060e871c05788fd562c3b3af5600c8d68b1"

