require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kate-${PV}.tar.xz"
SRC_URI[sha256sum] = "5c384b0fe9706840e4064c71a45069b80da0448c11bfa2debf9dd5953b8e17f0"
