require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kate-23.04.0.tar.xz"
SRC_URI[sha256sum] = "589c33501f98fa7937a7e3075c155e22a31f746ce4e5f15022b509c5fc1c1c0d"
