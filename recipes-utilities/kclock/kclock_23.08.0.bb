# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kclock-${PV}.tar.xz"
SRC_URI[sha256sum] = "3cbb9075ff6c57b196a305b3ac73b4f81a48711b11505a308a47b5433d406123"

