require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kclock-${PV}.tar.xz"
SRC_URI[sha256sum] = "251d86d65c1c57078de465031099c8be38a8587dfa5843ec486c6eaac920ba6b"
