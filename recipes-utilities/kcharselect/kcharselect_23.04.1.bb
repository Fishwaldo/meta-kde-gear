# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcharselect-${PV}.tar.xz"
SRC_URI[sha256sum] = "42be2ab146068f9185d7777660b6d830dc01c0928dca24eb79abade5534ee102"

