# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcharselect-${PV}.tar.xz"
SRC_URI[sha256sum] = "c565517e53511869c998ca6aff7a9d4f602e9c47358f460bf89f0396c1f18a2c"

