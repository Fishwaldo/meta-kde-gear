# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/print-manager-${PV}.tar.xz"
SRC_URI[sha256sum] = "9ba1b2c4c4f3cc52b61dfa9f63c352f612300ae3e4457e86b69f87871f5fe426"

