require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/print-manager-23.04.0.tar.xz"
SRC_URI[sha256sum] = "abe326ecf653a80ab88438ce28fe094d8fd3da964f2b6660b5bb609b868ac5bd"
