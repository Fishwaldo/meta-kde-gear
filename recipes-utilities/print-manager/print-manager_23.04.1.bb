require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/print-manager-${PV}.tar.xz"
SRC_URI[sha256sum] = "c0c042b9fe43d9e2f0e2b468d5c7faa7d8d2ecd1ce37c16b836958ac31d51bf7"
