# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/yakuake-${PV}.tar.xz"
SRC_URI[sha256sum] = "05836c72d7cc4d27f2069b45137d250fdbd73c108013af53e74de62c39cbe2e0"

