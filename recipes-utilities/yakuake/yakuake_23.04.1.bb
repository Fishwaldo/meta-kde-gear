# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/yakuake-${PV}.tar.xz"
SRC_URI[sha256sum] = "89b7e2c6a1e005405224f1a005b5c417b3d3ac43e799fc8316566f431c48dd21"

