# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktimer-${PV}.tar.xz"
SRC_URI[sha256sum] = "cffba0b014b867a2dfe8bd646ad22326648b325540b00062e531213fee43a897"

