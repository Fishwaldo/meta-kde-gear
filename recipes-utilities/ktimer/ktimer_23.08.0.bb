# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktimer-${PV}.tar.xz"
SRC_URI[sha256sum] = "4c6fba281f6e517b4eb9b88d90acc2279e43624173e096dbdab9aa91bb83b419"

