# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ark-${PV}.tar.xz"
SRC_URI[sha256sum] = "41fcf916a973beade18f043bbbd49bcf8329ae64fcf161e907e30d643f442526"

