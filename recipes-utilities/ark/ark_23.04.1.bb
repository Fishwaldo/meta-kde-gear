# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ark-${PV}.tar.xz"
SRC_URI[sha256sum] = "4852199db26733348cbf58495c7a1e5419c5dcd0acfdcf59dd39bc69f12325b4"

