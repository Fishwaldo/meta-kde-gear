# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kteatime-${PV}.tar.xz"
SRC_URI[sha256sum] = "1b88b59d4298033eff04c115d0874a1405e3f1181a51b17edb060ac259162b46"

