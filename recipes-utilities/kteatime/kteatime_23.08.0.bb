# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kteatime-${PV}.tar.xz"
SRC_URI[sha256sum] = "41b6428adae522a8c54cf6906205dde90c241ef3f5b193dda889ce2d81a7895b"

