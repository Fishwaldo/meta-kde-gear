# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/okteta/${PV}/src/okteta-${PV}.tar.xz"
SRC_URI[sha256sum] = "28a614f7e0c32b4917a5eaca7e0c6ecaca87b13191ab534ab404f5569b3c33fa"

