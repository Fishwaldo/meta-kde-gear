# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/markdownpart-${PV}.tar.xz"
SRC_URI[sha256sum] = "7e6c37e96188e59b95a824ef84465e7ea06c3066a3c8f4c647d466100fce18e5"

