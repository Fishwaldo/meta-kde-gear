# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/markdownpart-${PV}.tar.xz"
SRC_URI[sha256sum] = "d6970f5c19a083e357d80e09c65fec009ba81988f79bdd7a38cf4249ed7eb235"

