# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktrip-${PV}.tar.xz"
SRC_URI[sha256sum] = "958b372d1818f2074f97328983318cff3037a3eae04ee47004bb96cbd984fc15"

