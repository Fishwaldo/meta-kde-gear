# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktrip-${PV}.tar.xz"
SRC_URI[sha256sum] = "d7651c1644f6e8934b083e7de763a0f852bfba3269185f3aabe44604e59c7df8"

