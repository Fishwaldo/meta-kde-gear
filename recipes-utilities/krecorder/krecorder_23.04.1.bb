# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/krecorder-${PV}.tar.xz"
SRC_URI[sha256sum] = "50bca73fd2a0ea91cf2519521e79ce381aab9f9899b4e5fecc936e148b91fa9c"

