# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/krecorder-${PV}.tar.xz"
SRC_URI[sha256sum] = "a6c237349bdb22bf0dd39ee29ecc17e8213eae791e04b82ebe7fe70d7cc1161d"

