# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/sweeper-${PV}.tar.xz"
SRC_URI[sha256sum] = "f0c5f7fe8373cf49f7dd51ec416e6ad7c3b3c7e67ced62baa308a64bef38e5ad"

