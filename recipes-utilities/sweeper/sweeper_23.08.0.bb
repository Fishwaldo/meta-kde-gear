# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/sweeper-${PV}.tar.xz"
SRC_URI[sha256sum] = "6ac709de3ab720b3faeea6af5bae681bee2760fc9a1821b869e700f7131173bc"

