# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kalk-${PV}.tar.xz"
SRC_URI[sha256sum] = "0f5939fc9b69205b30b4e9e7eccb34d3f8de3616e088d7c68e2a087d7c785196"

