# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kalk-${PV}.tar.xz"
SRC_URI[sha256sum] = "9748ab955b115dda552e192eeae356ff14bfc9ece43f195da813419170689ca6"

