# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kfind-${PV}.tar.xz"
SRC_URI[sha256sum] = "61fdf586f786cbe50c83054b9f3e407a465cfb6a75e081254d022a326111591d"

