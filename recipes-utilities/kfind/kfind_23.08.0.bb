# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kfind-${PV}.tar.xz"
SRC_URI[sha256sum] = "b1c88999d50e059ded2cf5adb85882a5be7ba0595130905b19d989111fa85e73"

