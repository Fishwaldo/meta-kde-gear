# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/keysmith-${PV}.tar.xz"
SRC_URI[sha256sum] = "8e092306147358acf945e7968615d8ed76799d2f3916e686535d95fd70b8151b"

