# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/keysmith-${PV}.tar.xz"
SRC_URI[sha256sum] = "0159d96968ea97708d0cca2665aaf1468fa37bd05d4d90266407552458ca40f5"

