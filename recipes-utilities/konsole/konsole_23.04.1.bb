# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/konsole-${PV}.tar.xz"
SRC_URI[sha256sum] = "b9d1149afbf93cacc2c57c5b641511c871d5e70d929f7290d3bdf16b5b04b698"

