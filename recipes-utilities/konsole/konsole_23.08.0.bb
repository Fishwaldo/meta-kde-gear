# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/konsole-${PV}.tar.xz"
SRC_URI[sha256sum] = "31d26bd9454dcb93eb81222e83e91f1027164d578e9379bf81515d59f473fa9c"

