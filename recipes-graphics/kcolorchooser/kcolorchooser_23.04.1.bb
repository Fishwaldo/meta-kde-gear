# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcolorchooser-${PV}.tar.xz"
SRC_URI[sha256sum] = "ff9a3f68a381fb3dd12df98ea48144f9c6abbf962c434fb93f0bdcba0b49f329"

