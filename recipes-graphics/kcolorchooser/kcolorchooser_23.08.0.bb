# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kcolorchooser-${PV}.tar.xz"
SRC_URI[sha256sum] = "d781bec84bed93e687d604287de351484392c049a83c55970c153dde51f37d97"

