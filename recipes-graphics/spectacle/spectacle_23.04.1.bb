# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/spectacle-${PV}.tar.xz"
SRC_URI[sha256sum] = "064c2e4366a451a52cbd826fe6066d78e9e69419116b2d3f650187ac3b27824d"

