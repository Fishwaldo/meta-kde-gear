# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/spectacle-${PV}.tar.xz"
SRC_URI[sha256sum] = "383b1e7a38d7f70cce66452a6e47678718a3201e0e0a104323aeb8c97de2c1ee"

