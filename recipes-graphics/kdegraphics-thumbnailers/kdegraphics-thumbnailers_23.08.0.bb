# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdegraphics-thumbnailers-${PV}.tar.xz"
SRC_URI[sha256sum] = "a0882999353e283bd8ebada4b04bcd919997e906c12a1110d64d1b29e0345433"

