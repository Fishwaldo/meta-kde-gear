# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdegraphics-thumbnailers-${PV}.tar.xz"
SRC_URI[sha256sum] = "4511d37ddb6ab98f744a0a3b208d6d74ba71aa1dd1dc2db3d513ca39de6be3ae"

