# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kruler-${PV}.tar.xz"
SRC_URI[sha256sum] = "0a5ac79e1bac5f378560ff722b94fd10bb86858f5fbaad5b4c8fd5b2b58b1e04"

