# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kruler-${PV}.tar.xz"
SRC_URI[sha256sum] = "146c12c1da3a58d021715123652871bb6f2617eedd0b196180228bacaab7d786"

