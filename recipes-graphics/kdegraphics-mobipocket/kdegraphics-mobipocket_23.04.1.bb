# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdegraphics-mobipocket-${PV}.tar.xz"
SRC_URI[sha256sum] = "48dda7bfb67c46397eedb8966373199a34ccbb61a8b8369c7b2301b822cc6941"

