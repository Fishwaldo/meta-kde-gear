# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdegraphics-mobipocket-${PV}.tar.xz"
SRC_URI[sha256sum] = "15adc68f91b7eb873ccc3db09a1ae8e1a2c5d498455162b2c52cca97be7979fb"

