# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kolourpaint-${PV}.tar.xz"
SRC_URI[sha256sum] = "1bc953c210e4be7bb3477169f55cd3e897d3b19ae5a8b277400dde6a87a9a3b4"

