# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kolourpaint-${PV}.tar.xz"
SRC_URI[sha256sum] = "2718bed709218619ce7dc8199dd12fbc8143eb32e7d175db20b946d9770bf2d6"

