# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libksane-${PV}.tar.xz"
SRC_URI[sha256sum] = "3155c8ce0f167734e130440be3f29c8c24409854b18b10e1e41c631fc9626ae0"

