# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libksane-${PV}.tar.xz"
SRC_URI[sha256sum] = "aeafdb9bb23fb21e9be1d3b16e734f65abb926c265cc8743538c0823a79ea1ff"

