# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/skanlite-${PV}.tar.xz"
SRC_URI[sha256sum] = "e62b75d4733ceffc61e0f9c74b2cbd3cb4669c0952f00b3166cc6d31dd46cf6e"

