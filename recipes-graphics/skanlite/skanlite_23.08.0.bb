# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/skanlite-${PV}.tar.xz"
SRC_URI[sha256sum] = "4634bac9efaab27449bbd966c64ce5391152503b3e48fdd051bafb59d446d488"

