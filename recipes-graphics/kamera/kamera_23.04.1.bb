# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kamera-${PV}.tar.xz"
SRC_URI[sha256sum] = "8a5339d083e5c8ef88f0288373c3a3526d52faa89aa56dd4ce426c38006c5afc"

