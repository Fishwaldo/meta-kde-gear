# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kamera-${PV}.tar.xz"
SRC_URI[sha256sum] = "38abc2952e578c3eaee0c0a81fc19f4de35b2fe2a7fb14b7620aa1202b6499c4"

