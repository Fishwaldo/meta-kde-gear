# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkipi-${PV}.tar.xz"
SRC_URI[sha256sum] = "6b0f14cabbcccbb80bdcf7d2c9ac2e6b27ef660e9f56e8797847c9cd1ef21496"

