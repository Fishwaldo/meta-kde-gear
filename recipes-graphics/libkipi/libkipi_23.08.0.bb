# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkipi-${PV}.tar.xz"
SRC_URI[sha256sum] = "928ae3fe323231cbb78666fb9def552b8b8d77917f4adaa1f019401d3974e02f"

