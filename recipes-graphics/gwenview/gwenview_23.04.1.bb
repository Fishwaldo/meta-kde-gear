# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/gwenview-${PV}.tar.xz"
SRC_URI[sha256sum] = "b11c745999f20eaaa18c85d221063a77af28fc0e7a9176da651a5210fec8b0d5"

