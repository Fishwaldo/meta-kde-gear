# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/gwenview-23.04.0.tar.xz"
SRC_URI[sha256sum] = "b63d81b4471bd37526b0da8f283373df3f60c9a5ea7c9cc40d3baa599c76a50c"

