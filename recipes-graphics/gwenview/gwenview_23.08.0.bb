# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/gwenview-${PV}.tar.xz"
SRC_URI[sha256sum] = "027fde3f87cd8aba6ba4214031afbf7797dc23b5831293ed6a85cc1df2188aa7"

