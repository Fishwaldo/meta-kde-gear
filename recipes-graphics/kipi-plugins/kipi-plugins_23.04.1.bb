# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kipi-plugins-${PV}.tar.xz"
SRC_URI[sha256sum] = "a1bae98c52bea594f8ad17a39dede6fba5cac778f365164720a0e95e529598aa"

