# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kipi-plugins-${PV}.tar.xz"
SRC_URI[sha256sum] = "174475355efb437fc79e7c393ae58eed4cf9fa76abeac5138ce5a14658a93a6d"

