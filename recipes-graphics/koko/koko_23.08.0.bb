# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/release-service/${PV}/src/koko-${PV}.tar.xz"
SRC_URI[sha256sum] = "2d473afa9360e8f5bd0cc7cd0f983bb7e0e9da1cc86240c354e171d3119f27a2"

