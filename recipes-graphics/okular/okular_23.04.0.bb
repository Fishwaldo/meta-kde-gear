# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/okular-23.04.0.tar.xz"
SRC_URI[sha256sum] = "6c0dff299abf86df88d86e7d31d1dac2633775a2cca801ab3ca5104fafbcd40c"

