# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/okular-${PV}.tar.xz"
SRC_URI[sha256sum] = "9b46c544f975085298ee7978d552d3078c903a12611a6dbd038fc2b525996838"

