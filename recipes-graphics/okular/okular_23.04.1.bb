# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/okular-${PV}.tar.xz"
SRC_URI[sha256sum] = "1cc470f8695d9ac53163071aa8b78885efe813df77fb6456cd0946d3309c1db7"

