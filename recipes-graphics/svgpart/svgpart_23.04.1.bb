# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/svgpart-${PV}.tar.xz"
SRC_URI[sha256sum] = "8107ea771da256bfa0bcb31818c653df12c493c98cfa6a9d5e593a0740d361b4"

