# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/svgpart-${PV}.tar.xz"
SRC_URI[sha256sum] = "556a3b115a9339a3bbde582145afd92f4b220f68c24032eb323f3711e1d15e52"

