# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/colord-kde-${PV}.tar.xz"
SRC_URI[sha256sum] = "fff0b711379f5dc9ea3bcb4158b243d82925f05283e9d1a5949befe76734e75b"

