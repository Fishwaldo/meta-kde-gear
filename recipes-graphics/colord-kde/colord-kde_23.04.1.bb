# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/colord-kde-${PV}.tar.xz"
SRC_URI[sha256sum] = "3cea6404fe0fdccb6c9ce3af1112bbafbf4a813167317db99582c0f6040f6a0f"

