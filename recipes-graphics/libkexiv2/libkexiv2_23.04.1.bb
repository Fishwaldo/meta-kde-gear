require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkexiv2-${PV}.tar.xz"
SRC_URI[sha256sum] = "3a15410e0eaea3b3b0ca0fa274448d97e8172b5167a82f106c29dff6ba19e275"
