require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/libkdcraw-23.04.0.tar.xz"
SRC_URI[sha256sum] = "f7af5d51721c8852236ca875a969f7ad6ba223eaae1564614d7470582a901ba8"
