# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkdcraw-${PV}.tar.xz"
SRC_URI[sha256sum] = "a3cbb6df25a28003cddb47496c0831c7af2940dc4761a118db1b6c407100d847"

