require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkdcraw-${PV}.tar.xz"
SRC_URI[sha256sum] = "14a61b808443ff8b3a6566e5f6141278ed71af223b39a4b0c322dd137de51701"
