# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kimagemapeditor-${PV}.tar.xz"
SRC_URI[sha256sum] = "98a15260b415067e11d0940184b230ba60b19cf38d2cd6d754d1c2c7d8ba47d2"

