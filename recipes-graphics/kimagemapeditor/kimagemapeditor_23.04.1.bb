# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kimagemapeditor-${PV}.tar.xz"
SRC_URI[sha256sum] = "18ff19016a1798e3419191044d3e02c254048a3a055a33b04ca1451d7513cd36"

