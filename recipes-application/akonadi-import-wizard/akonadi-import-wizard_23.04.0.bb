require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/akonadi-import-wizard-23.04.0.tar.xz"
SRC_URI[sha256sum] = "0969c6d87f027af12af96243c1af124a7a03b511067c95d5e82ae7bc7503d59b"
