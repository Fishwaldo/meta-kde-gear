require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/libkdepim-23.04.0.tar.xz"
SRC_URI[sha256sum] = "605b1725c2dc656016ff3ea16e3119354caeb9e555e7de79dd752883d440ebcb"

