require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kaccounts-integration-23.04.0.tar.xz"
SRC_URI[sha256sum] = "9a068cf7579ca376a27abee31ca0b2a6544b0a08d1f204d88a4833c41d8ae698"
