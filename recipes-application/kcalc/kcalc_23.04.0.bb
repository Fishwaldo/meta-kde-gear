require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kcalc-23.04.0.tar.xz"
SRC_URI[sha256sum] = "d269b3d43c8fa26beda1007ab8f46a94e378337ad8261b6900565bc3e977da6a"
