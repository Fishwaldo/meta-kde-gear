# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/calendarsupport-23.04.0.tar.xz"
SRC_URI[sha256sum] = "2af0ccc66ec8d8b58a74da575413bf8b58bfee1619e82caa895343dc901232ca"

