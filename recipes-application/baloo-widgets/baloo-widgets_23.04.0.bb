# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/baloo-widgets-23.04.0.tar.xz"
SRC_URI[sha256sum] = "4eae3b9e4127e773daec2098969c7928b2ebc6908c26329b4a09da30b3125c95"

