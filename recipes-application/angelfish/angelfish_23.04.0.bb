require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/angelfish-23.04.0.tar.xz"
SRC_URI[sha256sum] = "8394abf209d8dc3ae5c61bd3adcb32875f7991913afbed5c1e41c460ddf0691b"
