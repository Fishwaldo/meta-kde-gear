require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kcalutils-23.04.0.tar.xz"
SRC_URI[sha256sum] = "9b62dc83f84151f71ee4766ecea38b23e266225b17e031fbb51ea480c09b5379"

