require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/libkgapi-23.04.0.tar.xz"
SRC_URI[sha256sum] = "aceb156db7c7caee88fd1ea57b3e06e94200e94196e4a420c3896db1709d6551"
