require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kontactinterface-23.04.0.tar.xz"
SRC_URI[sha256sum] = "d7475f9abdb4809eaaf5aa78c4ac96f5118d84ceaa0015f70d3ed73f6c029cbb"
