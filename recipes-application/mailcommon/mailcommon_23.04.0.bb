require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/mailcommon-23.04.0.tar.xz"
SRC_URI[sha256sum] = "f4ea4dcccaf5c35cb96e374e01ca8d6e40c2a92bd6e661834685a451cfc75951"
