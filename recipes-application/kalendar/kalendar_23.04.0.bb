require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kalendar-23.04.0.tar.xz"
SRC_URI[sha256sum] = "ee6331fb4b44c757f1d892961bbb8779b0d8dac3f667e208b037ae6d67f68766"
