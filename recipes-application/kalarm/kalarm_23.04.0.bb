require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kalarm-23.04.0.tar.xz"
SRC_URI[sha256sum] = "3aad46389998c50e587f2fa467b143ca978c3e04ed9de37d923f4e0b255aa131"

