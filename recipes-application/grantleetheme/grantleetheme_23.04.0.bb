require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/grantleetheme-23.04.0.tar.xz"
SRC_URI[sha256sum] = "5c6462d4cb4857460a61db4919081804e2451bc28f43a0b655ea8a37e7ab7395"
