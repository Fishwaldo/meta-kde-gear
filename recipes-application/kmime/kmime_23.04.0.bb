require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kmime-23.04.0.tar.xz"
SRC_URI[sha256sum] = "a3cfb0ad644060a333a44a233f8f946f5f9c80ca55294843a91b1eb58091b24b"
