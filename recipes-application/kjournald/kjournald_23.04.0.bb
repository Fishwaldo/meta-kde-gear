require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kjournald-23.04.0.tar.xz"
SRC_URI[sha256sum] = "7d77ea2835de88b7b53c169f21b89fd06ffb0111ac020f48cc0989ad33091c9e"
