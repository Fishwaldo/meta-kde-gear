require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/libkleo-23.04.0.tar.xz"
SRC_URI[sha256sum] = "ae210e3849395044be778cc7b92746e209be91722928c991a3324932adda6e69"
