require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kldap-23.04.0.tar.xz"
SRC_URI[sha256sum] = "b27a690c0502198caf334b8eab498fbd14ff7280d3bdadf2afd4904c29a84e31"
