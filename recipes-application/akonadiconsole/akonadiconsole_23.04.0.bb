require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/akonadiconsole-23.04.0.tar.xz"
SRC_URI[sha256sum] = "a0dc55f300b3a8f1baf2e7f6fec8fe6fa8275049ebaad5984c8a5d67da6c1a05"
