require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/kwalletmanager-23.04.0.tar.xz"
SRC_URI[sha256sum] = "fed842eaa53a2fdc0ef04d1a623388a0dde386bf8d0cdec55ac2f96d9eacc288"
