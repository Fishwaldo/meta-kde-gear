require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/messagelib-23.04.0.tar.xz \
           file://0001-Add-Qt-PrinterSupport.patch \
           "
SRC_URI[sha256sum] = "9f6263f032e8f93da2cf6e68da6f477587ab720020f46b7fb62cc71840f1afde"
