require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/libkexiv2-23.04.0.tar.xz"
SRC_URI[sha256sum] = "18d3eed06df9d1e31d8434ed9887e305aba176d0856e19a8cd3bdb555b80d391"
