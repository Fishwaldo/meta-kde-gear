require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/23.04.0/src/calindori-23.04.0.tar.xz"
SRC_URI[sha256sum] = "64c20ff927ca2368a6aa9b6922f8db26d6a2f2d8461d278eb4be329d07ffb164"
