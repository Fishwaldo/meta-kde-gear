# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kqtquickcharts-${PV}.tar.xz"
SRC_URI[sha256sum] = "d451bae3ab93b1ec8f552069fb7ecd0cebe982e9d818efb10d3c1ff65e173275"

