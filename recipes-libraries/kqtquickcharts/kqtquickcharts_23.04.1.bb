# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kqtquickcharts-${PV}.tar.xz"
SRC_URI[sha256sum] = "da7ffde9c7e3313813b39488a9ac4ae51a78f96433078146665d70e14af8bd76"

