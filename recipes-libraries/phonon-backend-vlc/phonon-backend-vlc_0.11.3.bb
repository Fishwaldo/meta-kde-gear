require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/phonon/phonon-backend-vlc/0.11.3/phonon-backend-vlc-0.11.3.tar.xz"
SRC_URI[sha256sum] = "5e69fdeccb060c7e6b5924cef2e65bee5a08ace4127005b95344ed3077dc6397"
