# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = " \
    git://invent.kde.org/libraries/kdsoap-ws-discovery-client.git;protocol=https;branch=master \
"
SRCREV = "b1d96db25c58e3df19b9d08efaa4b5847b19e247"