require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/futuresql/futuresql-0.1.1.tar.xz"
SRC_URI[sha256sum] = "e44ed8d5a9618b3ca7ba2983ed9c5f7572e6e0a5b199f94868834b71ccbebd43"
