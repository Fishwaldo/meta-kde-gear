# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kosmindoormap-${PV}.tar.xz"
SRC_URI[sha256sum] = "4dcd66f6004258c33cdb172f411790eadbedc265a54b70d7eabc91a5573e30f1"

