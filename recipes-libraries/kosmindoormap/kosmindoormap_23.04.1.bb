# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kosmindoormap-${PV}.tar.xz"
SRC_URI[sha256sum] = "0ef2bc48f49842dd2cab5f25bb46fac80d33169df14d37392c021ec9e8492c99"

