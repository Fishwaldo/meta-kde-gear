# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/baloo-widgets-${PV}.tar.xz"
SRC_URI[sha256sum] = "f47b6ddcded425137007c882c684dbe835057147a0ffa1b56d6865917601d65c"

