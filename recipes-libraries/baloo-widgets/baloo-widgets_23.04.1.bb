# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/baloo-widgets-${PV}.tar.xz"
SRC_URI[sha256sum] = "00461e9ca746ba77f164c57025f16da8baa3f5e1695730f153c26f17bfeed747"

