# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksanecore-${PV}.tar.xz"
SRC_URI[sha256sum] = "56bf27ca19b89eb73ed8c648e2ce1db1f822562009729946a589640f1231bdda"

