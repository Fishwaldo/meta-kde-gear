# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksanecore-${PV}.tar.xz"
SRC_URI[sha256sum] = "9216ed34ca17308ea459565cb8b0e270473c73e195400b5362595b999524048d"

