# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kopeninghours-${PV}.tar.xz"
SRC_URI[sha256sum] = "3e7dddc663ce6d934cbe50d48d412c4228c7b2f417e4bb8a809ab45eb9d9c8db"

