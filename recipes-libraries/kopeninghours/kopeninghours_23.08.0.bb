# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kopeninghours-${PV}.tar.xz"
SRC_URI[sha256sum] = "c9e3026a073afd2fe1373ad743ca40b9b1a2f0d27e57eb2f4d78ed91304e7d97"

