# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kpublictransport-${PV}.tar.xz"
SRC_URI[sha256sum] = "cf395c2a28f2df5454875523c061d3e661ca6cab5d00df1400b85f9ae467f253"

