# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kpublictransport-${PV}.tar.xz"
SRC_URI[sha256sum] = "d48b12a0a8ceb12381861297856bff935540ac0f4753d5d5af7d40ef4f8f95ea"
