# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/calindori-${PV}.tar.xz"
SRC_URI[sha256sum] = "ae8dfc11e6204c40d3c49c7f59bbafe05e04b787cf3083552480143bf4a3bf9d"

