# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/qmlkonsole-${PV}.tar.xz"
SRC_URI[sha256sum] = "7109b8f2f400d84991b14e92329d92d8f532434c6f60fc18e78180ad66ec01d8"

