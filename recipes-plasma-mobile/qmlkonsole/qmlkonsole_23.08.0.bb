# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/qmlkonsole-${PV}.tar.xz"
SRC_URI[sha256sum] = "8f4610520d4dde3083e304d3ba6eb1877755de32bc1e4808a3918f0c166cdf77"

