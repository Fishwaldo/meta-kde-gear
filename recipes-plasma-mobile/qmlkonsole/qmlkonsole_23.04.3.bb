# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/qmlkonsole-${PV}.tar.xz"
SRC_URI[sha256sum] = "32755ab335f04ee3e71eee046890b5f1c2f9a78889a966117fa28efc7e3ecc90"

