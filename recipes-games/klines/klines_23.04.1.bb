# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/klines-${PV}.tar.xz"
SRC_URI[sha256sum] = "975e0fc0564668b64b93547a5ae81870fa120be3b4c40f085bdcc683ab2db56b"

