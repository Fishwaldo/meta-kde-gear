# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/klines-${PV}.tar.xz"
SRC_URI[sha256sum] = "b8e13d1319e27151331432a790b3b3e98b61f77ded8629e3e12803f14ecc812a"

