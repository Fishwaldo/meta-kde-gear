# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdiamond-${PV}.tar.xz"
SRC_URI[sha256sum] = "02ad464aab2f868772e16d2f8dbb7b2cf2ee1146ef163947f275ba1d6a383508"

