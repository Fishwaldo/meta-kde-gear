# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kdiamond-${PV}.tar.xz"
SRC_URI[sha256sum] = "c0127bdb74e3b1599ddd812c518b2ac50d51802a2b29ace99df99fff86e3445f"

