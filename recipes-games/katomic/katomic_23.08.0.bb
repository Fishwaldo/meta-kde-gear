# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/katomic-${PV}.tar.xz"
SRC_URI[sha256sum] = "88f6028ac8a5b3ca82f207402f0bc91ff4fee547d54383612db570a5b4f6392b"

