# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/katomic-${PV}.tar.xz"
SRC_URI[sha256sum] = "5ff675c1e768c94843fd5d6527ab08ac5d33724d6771d6aa84f4891db04fc3a8"

