# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkdegames-${PV}.tar.xz"
SRC_URI[sha256sum] = "898bec75a22d62a37c8c28cdbcfee54ae2b8d3def639111502c134e1407a2e61"

