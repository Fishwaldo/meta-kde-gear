# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkdegames-${PV}.tar.xz"
SRC_URI[sha256sum] = "8799c705256b8d8735070058ecc6dea72c54e2500f179d9654ec2a86e41bcb8a"

