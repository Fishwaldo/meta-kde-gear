# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/killbots-${PV}.tar.xz"
SRC_URI[sha256sum] = "2b1803ae776a93e1dfc41c5f4c1f0236cec088cd314dd2378cf7a590b8c77430"

