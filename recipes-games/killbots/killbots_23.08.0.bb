# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/killbots-${PV}.tar.xz"
SRC_URI[sha256sum] = "dfb01a5a16520c186103f3b8a4ece0a795c5c230ab18ca7b5a213ffbc3ca1946"

