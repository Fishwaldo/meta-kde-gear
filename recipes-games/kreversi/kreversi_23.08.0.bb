# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kreversi-${PV}.tar.xz"
SRC_URI[sha256sum] = "da9c02a001707c99772f8722ca687ccf66e04a6d52a2286e677a6e77223991ac"

