# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kreversi-${PV}.tar.xz"
SRC_URI[sha256sum] = "124618c9207d2521d0a95cb133e3fa5e1404e02a2fd67b268c98151ad7f9f646"

