# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kollision-${PV}.tar.xz"
SRC_URI[sha256sum] = "2b25b9c31123edf2ef04ed3c1c3d4b83a80429697183bd601e90233201f40e49"

