# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kollision-${PV}.tar.xz"
SRC_URI[sha256sum] = "cefd79160a93ae0fb523ef09989dd369599dc89a1661d09504b2e5f96fa7c12b"

