# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/picmi-${PV}.tar.xz"
SRC_URI[sha256sum] = "8e61b5a1e3a4e4fcb35ad8d28173d8ae5f3884ff2a12539b22a02db3b9ec0a31"

