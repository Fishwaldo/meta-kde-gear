# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/picmi-${PV}.tar.xz"
SRC_URI[sha256sum] = "3eade1d234f2964ff1b9161707dd3d1cd474dce0d9ea43d38f9afb12ffd9d9fc"

