# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kiriki-${PV}.tar.xz"
SRC_URI[sha256sum] = "fa4b03d2c81daa9c215f1e1fba3133d20368b627809bf5ecabbb76a487e1160c"

