# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kiriki-${PV}.tar.xz"
SRC_URI[sha256sum] = "359d4bc0a1eac71ef66bcaa4fca301f5311fa9c9901ce127ecfcaa3cf7adb7d1"

