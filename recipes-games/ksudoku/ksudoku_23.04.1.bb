# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksudoku-${PV}.tar.xz"
SRC_URI[sha256sum] = "d0af66bd30a9ac64f57cd9094179bb3e9426b8e3c25ad6ac949dedde211c51e6"

