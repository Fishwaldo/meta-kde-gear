# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksudoku-${PV}.tar.xz"
SRC_URI[sha256sum] = "35f19136a43a54a3a6669b11cd700751a0c3623933bad42513063cbfb9cce233"

