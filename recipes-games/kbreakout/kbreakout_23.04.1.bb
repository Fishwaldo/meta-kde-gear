# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kbreakout-${PV}.tar.xz"
SRC_URI[sha256sum] = "7abe584feb88a07660e456d71ab42fbab5080681d01455822cb529278b241095"

