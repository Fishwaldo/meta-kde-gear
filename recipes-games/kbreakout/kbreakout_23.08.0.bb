# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kbreakout-${PV}.tar.xz"
SRC_URI[sha256sum] = "9d2c406eb5544cf2285d6ef1b1033610e680d15925270626d75cb9ae9c548dd7"

