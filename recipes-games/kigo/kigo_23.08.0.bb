# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kigo-${PV}.tar.xz"
SRC_URI[sha256sum] = "1cfcf1edd0be025e52bea64f199e1d4e6e61873712b4fc57d84a0cea696090ce"

