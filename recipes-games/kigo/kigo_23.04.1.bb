# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kigo-${PV}.tar.xz"
SRC_URI[sha256sum] = "ac66976fccb9507a656d27687f1148b4fb20f28b53243631fd4bdcb73f2c60ce"

