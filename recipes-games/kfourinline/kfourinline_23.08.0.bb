# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kfourinline-${PV}.tar.xz"
SRC_URI[sha256sum] = "10566dc67bb423d6041f934739518ffaf9f0f6b180774f04a533aba8b21fbd9f"

