# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kfourinline-${PV}.tar.xz"
SRC_URI[sha256sum] = "a7a052fffa4eee9730f5a38d51d7d2e6b1f79f0636211890aa5cc634e9ecba71"

