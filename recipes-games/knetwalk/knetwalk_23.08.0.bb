# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/knetwalk-${PV}.tar.xz"
SRC_URI[sha256sum] = "f47aee2077062bb402e579dccc7151488d25844731c02cf027ce5b48b0210772"

