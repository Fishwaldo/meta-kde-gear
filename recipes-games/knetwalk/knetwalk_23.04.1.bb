# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/knetwalk-${PV}.tar.xz"
SRC_URI[sha256sum] = "bab561ed7a45e355d1d40d415b60827eca7713f5ad43af8f2664d46bee6329ef"

