# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksirk-${PV}.tar.xz"
SRC_URI[sha256sum] = "d1a1074836c851568ccf451da16af48e5fad46e66e35daf71e6829a6d7922b77"

