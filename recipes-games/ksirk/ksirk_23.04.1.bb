# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksirk-${PV}.tar.xz"
SRC_URI[sha256sum] = "5bf8124e9a74a9161f11c6fc2fcd41bd42e443418688781331c135a90c7702d8"

