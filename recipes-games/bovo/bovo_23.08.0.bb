# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/bovo-${PV}.tar.xz"
SRC_URI[sha256sum] = "68c47cad1e908dcbffc68ecb14f57fab37d11fc81cc3ca0dbe953487c7c7f405"

