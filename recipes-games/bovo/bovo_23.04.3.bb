# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/bovo-${PV}.tar.xz"
SRC_URI[sha256sum] = "21c2b82b04f14ef12f5179ed19a97eece8634b0cd743a785d2c4b19a4933bafd"

