# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/bovo-${PV}.tar.xz"
SRC_URI[sha256sum] = "9b2453fa0fe1aeb56b8248d9d82d2ca2a257f95877b2585d6f96e6c0caef7128"

