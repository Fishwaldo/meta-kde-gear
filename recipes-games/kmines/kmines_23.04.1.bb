# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmines-${PV}.tar.xz"
SRC_URI[sha256sum] = "2afdabe967d57766b2e6020b292e9d893af28b5360ef1c7b6938419ea0253354"

