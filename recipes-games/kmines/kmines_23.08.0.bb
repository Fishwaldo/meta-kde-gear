# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kmines-${PV}.tar.xz"
SRC_URI[sha256sum] = "f33b68ddba89e77eea361d40d4eaa648479c1b1b438ee5e1116d744b3be89983"

