# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/lskat-${PV}.tar.xz"
SRC_URI[sha256sum] = "856e61d1e50a1d00076eea29b622483e590eb422fc15cd7ae03b31f629f85d87"

