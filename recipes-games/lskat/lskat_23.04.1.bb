# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/lskat-${PV}.tar.xz"
SRC_URI[sha256sum] = "63900127f930e02b00d1d9028ccb8977459c8cb8d10d1503b01df2b4617d66dc"

