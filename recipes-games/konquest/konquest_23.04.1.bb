# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/konquest-${PV}.tar.xz"
SRC_URI[sha256sum] = "82a4921f2fc53908a48517237e990dd844efbc618757062c5e3db3ce616394d0"

