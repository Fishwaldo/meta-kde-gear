# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/konquest-${PV}.tar.xz"
SRC_URI[sha256sum] = "975abedd1f031f777b2221d116414a76d06251d97ae8503d0cce14fb9ad71324"

