# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kspaceduel-${PV}.tar.xz"
SRC_URI[sha256sum] = "340bd7de7eeef75cb266de6e9ca9b9d44b39f0776338cd8f9dc6e7c0118d9eb6"

