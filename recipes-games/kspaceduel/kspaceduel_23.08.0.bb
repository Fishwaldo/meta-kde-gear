# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kspaceduel-${PV}.tar.xz"
SRC_URI[sha256sum] = "dc77fb65a37fd887494b49fd2f709c8d49193371ad1277e6e39beaf53bd2d105"

