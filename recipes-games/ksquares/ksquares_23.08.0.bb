# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksquares-${PV}.tar.xz"
SRC_URI[sha256sum] = "2054a60ed6fec6932da9ebe21b3fc1dc368536f4d55ac2c5c221e9b73f1acffa"

