# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksquares-${PV}.tar.xz"
SRC_URI[sha256sum] = "3056068281c947722ba46334ce68a795733dc552cd01debbd98119f0a15de53e"

