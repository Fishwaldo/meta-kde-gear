# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksnakeduel-${PV}.tar.xz"
SRC_URI[sha256sum] = "1231483d5d4b7185ec15ecd9af8e0491c4d973d96789042bfd642e4ff0a517e2"

