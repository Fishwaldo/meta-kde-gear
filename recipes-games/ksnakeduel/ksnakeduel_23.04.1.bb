# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ksnakeduel-${PV}.tar.xz"
SRC_URI[sha256sum] = "4612b983fcaeb2c2e8fafaf9be0dc9752ead242ff2644986ac6881432c81e0c3"

