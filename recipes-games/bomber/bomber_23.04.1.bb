# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/bomber-${PV}.tar.xz"
SRC_URI[sha256sum] = "03c772388908c17e887fc724a48b2a8d19d3aaee0883c96c9fd764673e8eae7c"

