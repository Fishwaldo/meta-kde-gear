# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/bomber-${PV}.tar.xz"
SRC_URI[sha256sum] = "82693d6f8bf3888f0c5255cbeaf7e8eadc2820a4bef0329c2c3d65492ab1c0a6"

