# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/knights-${PV}.tar.xz"
SRC_URI[sha256sum] = "6f79e689dc545628f85e393a63d1d11bf56461ccbc2b37e5a58a9a37f22ecf7a"

