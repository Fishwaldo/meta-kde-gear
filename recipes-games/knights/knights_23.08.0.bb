# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/knights-${PV}.tar.xz"
SRC_URI[sha256sum] = "a64610b28b2b2f87f0f9b02aba6fe3d3be62de6f81139a1ff126e6d8b6d654e2"

