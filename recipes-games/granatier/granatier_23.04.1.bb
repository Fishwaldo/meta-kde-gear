# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/granatier-${PV}.tar.xz"
SRC_URI[sha256sum] = "f02478334d46295f10d9b26196d1ef17e9da1fbffc070451932bb33911b23be4"

