# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/granatier-${PV}.tar.xz"
SRC_URI[sha256sum] = "99cb6347669303541da9bcd2232c1951834a0154172e245aa5b1b205b61cdb43"

