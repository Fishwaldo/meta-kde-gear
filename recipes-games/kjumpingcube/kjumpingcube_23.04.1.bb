# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kjumpingcube-${PV}.tar.xz"
SRC_URI[sha256sum] = "1b577e52ad1385f646c32c2419dbf595346a1e6aafe0a900ed2c5db44fd8f91e"

