# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kjumpingcube-${PV}.tar.xz"
SRC_URI[sha256sum] = "29a196d0d92ba618e2574e7590c1d4f38a1f5ca60a61ea00608ea45807cf3f3f"

