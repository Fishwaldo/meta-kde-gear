# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/palapeli-${PV}.tar.xz"
SRC_URI[sha256sum] = "403bf461a2027800ba555afa9c9624d61dfa17764a75cfd49f121dad7c4ab229"

