# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/palapeli-${PV}.tar.xz"
SRC_URI[sha256sum] = "340ca8d5730743ece11fa18f98722bb64206a90c7d3f7a445bc7ff2d24eb9da5"

