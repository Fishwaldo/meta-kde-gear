# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kblackbox-${PV}.tar.xz"
SRC_URI[sha256sum] = "e4321ac7471fa0cd3774fede14c2eabf5c25391071972ecf97e763c074e42859"

