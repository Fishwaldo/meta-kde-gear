# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kblackbox-${PV}.tar.xz"
SRC_URI[sha256sum] = "7e33a8a2356459510ff07c7fd29953ad69f0f69153f000227b6533e221fbbeab"

