# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/knavalbattle-${PV}.tar.xz"
SRC_URI[sha256sum] = "4debc2535daa8424ec11702553ef5dba605f66c51aa213f6c1ce1c3333940682"

