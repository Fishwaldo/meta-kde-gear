# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/knavalbattle-${PV}.tar.xz"
SRC_URI[sha256sum] = "193f5cb1f1ce1cb01686aa572ca6d08f7da19c7b711ff5290dfff5ca16b9df6d"

