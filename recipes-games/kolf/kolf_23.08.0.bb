# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kolf-${PV}.tar.xz"
SRC_URI[sha256sum] = "8987c71c02e8d9c843e03922c7a1cc1b4608cad221cf35cedeac34faa8d9dfcc"

