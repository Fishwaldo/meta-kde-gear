# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kolf-${PV}.tar.xz"
SRC_URI[sha256sum] = "4d9511702bc792d8a38b52fd2862b36576dd492e5b9b3f03e664639b29c476b2"

