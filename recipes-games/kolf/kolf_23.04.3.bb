# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kolf-${PV}.tar.xz"
SRC_URI[sha256sum] = "1b7a2bb60cbe3d095e7c2d4c1f228326148b6d577fe12bf497355ac328bb6d71"

