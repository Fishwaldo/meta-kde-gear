# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktuberling-${PV}.tar.xz"
SRC_URI[sha256sum] = "162443c9bbebdfeb4a6dc82fe33e8e98a049a32e6bee723c3b1b6df11400eb66"

