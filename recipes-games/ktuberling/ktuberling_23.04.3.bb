# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktuberling-${PV}.tar.xz"
SRC_URI[sha256sum] = "f37c1fa9069adda54144302254d56dcdbfe5613db81f29f429a6087265e4677e"

