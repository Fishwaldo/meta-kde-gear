# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/ktuberling-${PV}.tar.xz"
SRC_URI[sha256sum] = "c7ff8f0eacc0487c3991ba615852acdfca37a6c76b620dedede052b52f2387f1"

