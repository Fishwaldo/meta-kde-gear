# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kgoldrunner-${PV}.tar.xz"
SRC_URI[sha256sum] = "b630dae7b1600b0f4f82ce7712bfd1b8514a941a822197673d249f5d3ac5bf93"

