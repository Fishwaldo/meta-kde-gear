# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kgoldrunner-${PV}.tar.xz"
SRC_URI[sha256sum] = "cd93fa9c283236d5c6e49abca5524cc1af6bcdf6a6830030d5b1c7f02c80c5ea"

