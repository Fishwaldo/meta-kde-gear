# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kapman-${PV}.tar.xz"
SRC_URI[sha256sum] = "90bffde2811548faa9d3ba37aaf171780889025aeae23716edc84b2a0e17ec08"

