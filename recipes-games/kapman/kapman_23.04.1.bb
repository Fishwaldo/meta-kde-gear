# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kapman-${PV}.tar.xz"
SRC_URI[sha256sum] = "a66266e38d5467665b3e2527be0579e25e461d22f4d53ef6e7ccd6f0427350f0"

