# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkmahjongg-${PV}.tar.xz"
SRC_URI[sha256sum] = "08c18da4df11b48df69294eb50327543574f518b4b06be3e05ab365cfae3b8e4"

