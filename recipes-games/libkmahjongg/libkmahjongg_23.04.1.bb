# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkmahjongg-${PV}.tar.xz"
SRC_URI[sha256sum] = "bcedcc78f622a37270c5ed41016a3cb41771c9958bbe5cbe6e7c6bbc38d64498"

