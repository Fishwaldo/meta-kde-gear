# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kblocks-${PV}.tar.xz"
SRC_URI[sha256sum] = "14871763a56f8d0406ff807035d68d0c7fef11f11ba99575bfa8002e452425bb"

