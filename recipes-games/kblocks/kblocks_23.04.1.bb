# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kblocks-${PV}.tar.xz"
SRC_URI[sha256sum] = "b3848f277ec0b4fb32f5dda0d49ce6645bc174e10881b0e2dbe3be2db22ca580"

