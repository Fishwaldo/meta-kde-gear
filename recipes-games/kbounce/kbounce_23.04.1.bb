# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kbounce-${PV}.tar.xz"
SRC_URI[sha256sum] = "db1ecf31fd49aabb5554254ceff09a7eec3471d6819bbff3f0a1b89e0c954456"

