# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kbounce-${PV}.tar.xz"
SRC_URI[sha256sum] = "5d2670d06dd51c72f8c6cf0757cb352bdfdd062ff9f2b8315258ee26faf49c8e"

