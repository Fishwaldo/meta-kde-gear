# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/klickety-${PV}.tar.xz"
SRC_URI[sha256sum] = "ff231cca66f367094327e08938a7d4ae30551006a77aa0180c1828223f701785"

