# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/klickety-${PV}.tar.xz"
SRC_URI[sha256sum] = "5b766444fdeab4dd6cf6f556b2d10ea26bf40015af027fdb290fbd97c4dd88ed"

